* Functional test stimulus file for 10ns period

* TT process corner
.lib "/home/yunus/OpenLane/pdks/sky130A/libs.tech/ngspice/sky130.lib.spice" tt
.include "sram_32_16_sky130.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsram_32_16_sky130 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 a0_0 a0_1 a0_2 a0_3 a0_4 CSB0 WEB0 clk0 SPARE_WEN0_0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 vdd gnd sram_32_16_sky130

* SRAM output loads
CD00 dout0_0  0 27.56f
CD01 dout0_1  0 27.56f
CD02 dout0_2  0 27.56f
CD03 dout0_3  0 27.56f
CD04 dout0_4  0 27.56f
CD05 dout0_5  0 27.56f
CD06 dout0_6  0 27.56f
CD07 dout0_7  0 27.56f
CD08 dout0_8  0 27.56f
CD09 dout0_9  0 27.56f
CD010 dout0_10  0 27.56f
CD011 dout0_11  0 27.56f
CD012 dout0_12  0 27.56f
CD013 dout0_13  0 27.56f
CD014 dout0_14  0 27.56f
CD015 dout0_15  0 27.56f
CD016 dout0_16  0 27.56f
CD017 dout0_17  0 27.56f
CD018 dout0_18  0 27.56f
CD019 dout0_19  0 27.56f
CD020 dout0_20  0 27.56f
CD021 dout0_21  0 27.56f
CD022 dout0_22  0 27.56f
CD023 dout0_23  0 27.56f
CD024 dout0_24  0 27.56f
CD025 dout0_25  0 27.56f
CD026 dout0_26  0 27.56f
CD027 dout0_27  0 27.56f
CD028 dout0_28  0 27.56f
CD029 dout0_29  0 27.56f
CD030 dout0_30  0 27.56f
CD031 dout0_31  0 27.56f
CD032 dout0_32  0 27.56f

* Important signals for debug
* bl:	xsram_32_16_sky130.xbank0.bl_0_0
* br:	xsram_32_16_sky130.xbank0.br_0_0
* s_en:	xsram_32_16_sky130.s_en
* q:	xsram_32_16_sky130.xbank0.xbitcell_array.xbitcell_array.xrow_0_col_0_bitcell.Q
* qbar:	xsram_32_16_sky130.xbank0.xbitcell_array.xbitcell_array.xrow_0_col_0_bitcell.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 10ns)
*	Writing 0+00011000111010100111011000110010  to  address 01111 (from port 0) during cycle 1 (10ns - 20ns)
*	Writing 0+10110000011111111000101101001111  to  address 01111 (from port 0) during cycle 2 (20ns - 30ns)
*	Writing 0+10111000010111010010010001000110  to  address 00000 (from port 0) during cycle 3 (30ns - 40ns)
*	Reading 0+10111000010111010010010001000110 from address 00000 (from port 0) during cycle 4 (40ns - 50ns)
*	Reading 0+10111000010111010010010001000110 from address 00000 (from port 0) during cycle 5 (50ns - 60ns)
*	Reading 0+10111000010111010010010001000110 from address 00000 (from port 0) during cycle 6 (60ns - 70ns)
*	Writing 0+10000101101000101001011011111000  to  address 01111 (from port 0) during cycle 8 (80ns - 90ns)
*	Writing 0+10100111011101010111001101110011  to  address 01111 (from port 0) during cycle 9 (90ns - 100ns)
*	Reading 0+10100111011101010111001101110011 from address 01111 (from port 0) during cycle 10 (100ns - 110ns)
*	Reading 0+10111000010111010010010001000110 from address 00000 (from port 0) during cycle 11 (110ns - 120ns)
*	Writing 0+10011010001111101000011100101111  to  address 01111 (from port 0) during cycle 12 (120ns - 130ns)
*	Writing 0+00010111100100011100110100111000  to  address 01111 (from port 0) during cycle 13 (130ns - 140ns)
*	Writing 0+10011010101000110001010111101110  to  address 00000 (from port 0) during cycle 15 (150ns - 160ns)
*	Reading 0+00010111100100011100110100111000 from address 01111 (from port 0) during cycle 16 (160ns - 170ns)
*	Reading 0+00010111100100011100110100111000 from address 01111 (from port 0) during cycle 18 (180ns - 190ns)
*	Reading 0+00010111100100011100110100111000 from address 01111 (from port 0) during cycle 19 (190ns - 200ns)
*	Reading 0+00010111100100011100110100111000 from address 01111 (from port 0) during cycle 20 (200ns - 210ns)
*	Reading 0+00010111100100011100110100111000 from address 01111 (from port 0) during cycle 21 (210ns - 220ns)
*	Reading 0+00010111100100011100110100111000 from address 01111 (from port 0) during cycle 23 (230ns - 240ns)
*	Writing 0+10100010101101111010111111101111  to  address 00000 (from port 0) during cycle 25 (250ns - 260ns)
*	Reading 0+10100010101101111010111111101111 from address 00000 (from port 0) during cycle 26 (260ns - 270ns)
*	Reading 0+10100010101101111010111111101111 from address 00000 (from port 0) during cycle 28 (280ns - 290ns)
*	Writing 0+01111000111110100110111011100011  to  address 00000 (from port 0) during cycle 29 (290ns - 300ns)
*	Writing 0+11100001111101110011100111011000  to  address 01111 (from port 0) during cycle 30 (300ns - 310ns)
*	Writing 0+10101110001001110001011010000101  to  address 00000 (from port 0) during cycle 31 (310ns - 320ns)
*	Reading 0+11100001111101110011100111011000 from address 01111 (from port 0) during cycle 32 (320ns - 330ns)
*	Reading 0+10101110001001110001011010000101 from address 00000 (from port 0) during cycle 33 (330ns - 340ns)
*	Reading 0+11100001111101110011100111011000 from address 01111 (from port 0) during cycle 34 (340ns - 350ns)
*	Reading 0+10101110001001110001011010000101 from address 00000 (from port 0) during cycle 35 (350ns - 360ns)
*	Reading 0+11100001111101110011100111011000 from address 01111 (from port 0) during cycle 38 (380ns - 390ns)
*	Reading 0+10101110001001110001011010000101 from address 00000 (from port 0) during cycle 39 (390ns - 400ns)
*	Writing 0+00110100110101111000000001101101  to  address 01111 (from port 0) during cycle 41 (410ns - 420ns)
*	Reading 0+00110100110101111000000001101101 from address 01111 (from port 0) during cycle 42 (420ns - 430ns)
*	Reading 0+00110100110101111000000001101101 from address 01111 (from port 0) during cycle 43 (430ns - 440ns)
*	Reading 0+10101110001001110001011010000101 from address 00000 (from port 0) during cycle 44 (440ns - 450ns)
*	Reading 0+10101110001001110001011010000101 from address 00000 (from port 0) during cycle 45 (450ns - 460ns)
*	Reading 0+10101110001001110001011010000101 from address 00000 (from port 0) during cycle 46 (460ns - 470ns)
*	Reading 0+00110100110101111000000001101101 from address 01111 (from port 0) during cycle 47 (470ns - 480ns)
*	Writing 0+10011101100001110100010001011110  to  address 01111 (from port 0) during cycle 48 (480ns - 490ns)
*	Reading 0+10101110001001110001011010000101 from address 00000 (from port 0) during cycle 50 (500ns - 510ns)
*	Writing 0+00110010111001110000101010111101  to  address 01111 (from port 0) during cycle 51 (510ns - 520ns)
*	Reading 0+00110010111001110000101010111101 from address 01111 (from port 0) during cycle 54 (540ns - 550ns)
*	Writing 0+00010100101010100001110100110100  to  address 00000 (from port 0) during cycle 56 (560ns - 570ns)
*	Writing 0+11001000111111000011101110100010  to  address 00000 (from port 0) during cycle 57 (570ns - 580ns)
*	Reading 0+11001000111111000011101110100010 from address 00000 (from port 0) during cycle 58 (580ns - 590ns)
*	Writing 0+01111101110010010001010111100110  to  address 00000 (from port 0) during cycle 59 (590ns - 600ns)
*	Reading 0+00110010111001110000101010111101 from address 01111 (from port 0) during cycle 61 (610ns - 620ns)
*	Writing 0+11011010011110101101111001001011  to  address 00000 (from port 0) during cycle 62 (620ns - 630ns)
*	Reading 0+11011010011110101101111001001011 from address 00000 (from port 0) during cycle 63 (630ns - 640ns)
*	Reading 0+00110010111001110000101010111101 from address 01111 (from port 0) during cycle 64 (640ns - 650ns)
*	Reading 0+11011010011110101101111001001011 from address 00000 (from port 0) during cycle 65 (650ns - 660ns)
*	Reading 0+11011010011110101101111001001011 from address 00000 (from port 0) during cycle 67 (670ns - 680ns)
*	Reading 0+00110010111001110000101010111101 from address 01111 (from port 0) during cycle 68 (680ns - 690ns)
*	Writing 0+10010001110011110000111010000111  to  address 00000 (from port 0) during cycle 69 (690ns - 700ns)
*	Writing 0+10111010111101011111011011100111  to  address 01111 (from port 0) during cycle 70 (700ns - 710ns)
*	Reading 0+10010001110011110000111010000111 from address 00000 (from port 0) during cycle 71 (710ns - 720ns)
*	Writing 0+00111101111011100111101000101011  to  address 01111 (from port 0) during cycle 72 (720ns - 730ns)
*	Reading 0+00111101111011100111101000101011 from address 01111 (from port 0) during cycle 76 (760ns - 770ns)
*	Writing 0+10011011011110100111100010010100  to  address 01111 (from port 0) during cycle 77 (770ns - 780ns)
*	Writing 0+11100110000110011110011001100000  to  address 01111 (from port 0) during cycle 78 (780ns - 790ns)
*	Writing 0+00000000100110001011100000101110  to  address 01111 (from port 0) during cycle 79 (790ns - 800ns)
*	Writing 0+11011111000100111100110001111011  to  address 00000 (from port 0) during cycle 80 (800ns - 810ns)
*	Writing 0+10101101000100100110111100111001  to  address 00000 (from port 0) during cycle 81 (810ns - 820ns)
*	Reading 0+00000000100110001011100000101110 from address 01111 (from port 0) during cycle 82 (820ns - 830ns)
*	Reading 0+10101101000100100110111100111001 from address 00000 (from port 0) during cycle 83 (830ns - 840ns)
*	Reading 0+10101101000100100110111100111001 from address 00000 (from port 0) during cycle 84 (840ns - 850ns)
*	Writing 0+00101010011000011010001110010111  to  address 01111 (from port 0) during cycle 85 (850ns - 860ns)
*	Reading 0+10101101000100100110111100111001 from address 00000 (from port 0) during cycle 87 (870ns - 880ns)
*	Reading 0+10101101000100100110111100111001 from address 00000 (from port 0) during cycle 88 (880ns - 890ns)
*	Reading 0+10101101000100100110111100111001 from address 00000 (from port 0) during cycle 90 (900ns - 910ns)
*	Reading 0+00101010011000011010001110010111 from address 01111 (from port 0) during cycle 91 (910ns - 920ns)
*	Writing 0+10010100011100101001110101111110  to  address 00000 (from port 0) during cycle 92 (920ns - 930ns)
*	Reading 0+10010100011100101001110101111110 from address 00000 (from port 0) during cycle 93 (930ns - 940ns)
*	Reading 0+10010100011100101001110101111110 from address 00000 (from port 0) during cycle 96 (960ns - 970ns)
*	Reading 0+10010100011100101001110101111110 from address 00000 (from port 0) during cycle 97 (970ns - 980ns)
*	Writing 0+00001001000111101010110100111101  to  address 00000 (from port 0) during cycle 98 (980ns - 990ns)
*	Reading 0+00001001000111101010110100111101 from address 00000 (from port 0) during cycle 99 (990ns - 1000ns)
*	Reading 0+00101010011000011010001110010111 from address 01111 (from port 0) during cycle 101 (1010ns - 1020ns)
*	Reading 0+00001001000111101010110100111101 from address 00000 (from port 0) during cycle 102 (1020ns - 1030ns)
*	Reading 0+00101010011000011010001110010111 from address 01111 (from port 0) during cycle 103 (1030ns - 1040ns)
*	Writing 0+10100000010110010000001001000011  to  address 00000 (from port 0) during cycle 104 (1040ns - 1050ns)
*	Writing 0+10000101001100001000000001101100  to  address 01111 (from port 0) during cycle 106 (1060ns - 1070ns)
*	Reading 0+10100000010110010000001001000011 from address 00000 (from port 0) during cycle 107 (1070ns - 1080ns)
*	Reading 0+10000101001100001000000001101100 from address 01111 (from port 0) during cycle 108 (1080ns - 1090ns)
*	Reading 0+10000101001100001000000001101100 from address 01111 (from port 0) during cycle 109 (1090ns - 1100ns)
*	Reading 0+10100000010110010000001001000011 from address 00000 (from port 0) during cycle 110 (1100ns - 1110ns)
*	Reading 0+10000101001100001000000001101100 from address 01111 (from port 0) during cycle 111 (1110ns - 1120ns)
*	Reading 0+10000101001100001000000001101100 from address 01111 (from port 0) during cycle 112 (1120ns - 1130ns)
*	Reading 0+10100000010110010000001001000011 from address 00000 (from port 0) during cycle 113 (1130ns - 1140ns)
*	Reading 0+10000101001100001000000001101100 from address 01111 (from port 0) during cycle 114 (1140ns - 1150ns)
*	Reading 0+10000101001100001000000001101100 from address 01111 (from port 0) during cycle 115 (1150ns - 1160ns)
*	Reading 0+10000101001100001000000001101100 from address 01111 (from port 0) during cycle 116 (1160ns - 1170ns)
*	Reading 0+10000101001100001000000001101100 from address 01111 (from port 0) during cycle 117 (1170ns - 1180ns)
*	Reading 0+10000101001100001000000001101100 from address 01111 (from port 0) during cycle 118 (1180ns - 1190ns)
*	Reading 0+10000101001100001000000001101100 from address 01111 (from port 0) during cycle 120 (1200ns - 1210ns)
*	Writing 0+01010010010100111111010011111001  to  address 01111 (from port 0) during cycle 121 (1210ns - 1220ns)
*	Reading 0+10100000010110010000001001000011 from address 00000 (from port 0) during cycle 122 (1220ns - 1230ns)
*	Reading 0+10100000010110010000001001000011 from address 00000 (from port 0) during cycle 123 (1230ns - 1240ns)
*	Writing 0+11101010011001011000000110111100  to  address 00000 (from port 0) during cycle 124 (1240ns - 1250ns)
*	Reading 0+01010010010100111111010011111001 from address 01111 (from port 0) during cycle 125 (1250ns - 1260ns)
*	Reading 0+11101010011001011000000110111100 from address 00000 (from port 0) during cycle 127 (1270ns - 1280ns)
*	Reading 0+01010010010100111111010011111001 from address 01111 (from port 0) during cycle 128 (1280ns - 1290ns)
*	Writing 0+11011000100101110010010011111010  to  address 00000 (from port 0) during cycle 129 (1290ns - 1300ns)
*	Writing 0+11100101110001101010011101111101  to  address 01111 (from port 0) during cycle 130 (1300ns - 1310ns)
*	Writing 0+11111010011001101010001101000110  to  address 00000 (from port 0) during cycle 131 (1310ns - 1320ns)
*	Reading 0+11111010011001101010001101000110 from address 00000 (from port 0) during cycle 133 (1330ns - 1340ns)
*	Writing 0+11110011101010111111111111011111  to  address 00000 (from port 0) during cycle 135 (1350ns - 1360ns)
*	Reading 0+11110011101010111111111111011111 from address 00000 (from port 0) during cycle 137 (1370ns - 1380ns)
*	Reading 0+11110011101010111111111111011111 from address 00000 (from port 0) during cycle 139 (1390ns - 1400ns)
*	Reading 0+11100101110001101010011101111101 from address 01111 (from port 0) during cycle 140 (1400ns - 1410ns)
*	Reading 0+11110011101010111111111111011111 from address 00000 (from port 0) during cycle 142 (1420ns - 1430ns)
*	Writing 0+00100100011001000101010111011011  to  address 00000 (from port 0) during cycle 143 (1430ns - 1440ns)
*	Reading 0+11100101110001101010011101111101 from address 01111 (from port 0) during cycle 144 (1440ns - 1450ns)
*	Writing 0+00101100000011001000100011000111  to  address 01111 (from port 0) during cycle 146 (1460ns - 1470ns)
*	Writing 0+01110100001111010100110001010111  to  address 01111 (from port 0) during cycle 147 (1470ns - 1480ns)
*	Writing 0+01101010011111111010100111110000  to  address 01111 (from port 0) during cycle 148 (1480ns - 1490ns)
*	Reading 0+00100100011001000101010111011011 from address 00000 (from port 0) during cycle 149 (1490ns - 1500ns)
*	Reading 0+01101010011111111010100111110000 from address 01111 (from port 0) during cycle 150 (1500ns - 1510ns)
*	Writing 0+00001100010101001101101110100111  to  address 00000 (from port 0) during cycle 153 (1530ns - 1540ns)
*	Reading 0+00001100010101001101101110100111 from address 00000 (from port 0) during cycle 154 (1540ns - 1550ns)
*	Reading 0+01101010011111111010100111110000 from address 01111 (from port 0) during cycle 156 (1560ns - 1570ns)
*	Writing 0+00101001111101110000101100010100  to  address 01111 (from port 0) during cycle 157 (1570ns - 1580ns)
*	Reading 0+00101001111101110000101100010100 from address 01111 (from port 0) during cycle 159 (1590ns - 1600ns)
*	Reading 0+00101001111101110000101100010100 from address 01111 (from port 0) during cycle 160 (1600ns - 1610ns)
*	Reading 0+00101001111101110000101100010100 from address 01111 (from port 0) during cycle 161 (1610ns - 1620ns)
*	Reading 0+00101001111101110000101100010100 from address 01111 (from port 0) during cycle 162 (1620ns - 1630ns)
*	Writing 0+00111001110010011000011100101100  to  address 01111 (from port 0) during cycle 163 (1630ns - 1640ns)
*	Writing 0+11110110111101100010101101001000  to  address 01111 (from port 0) during cycle 164 (1640ns - 1650ns)
*	Writing 0+01100011011100001000000001100111  to  address 01111 (from port 0) during cycle 167 (1670ns - 1680ns)
*	Reading 0+00001100010101001101101110100111 from address 00000 (from port 0) during cycle 168 (1680ns - 1690ns)
*	Reading 0+01100011011100001000000001100111 from address 01111 (from port 0) during cycle 170 (1700ns - 1710ns)
*	Writing 0+10011111110100111011100000001001  to  address 01111 (from port 0) during cycle 171 (1710ns - 1720ns)
*	Writing 0+10001101011001100010001111001111  to  address 00000 (from port 0) during cycle 172 (1720ns - 1730ns)
*	Writing 0+00011100111111100011111010111100  to  address 00000 (from port 0) during cycle 173 (1730ns - 1740ns)
*	Writing 0+01111111011111011001111110111011  to  address 01111 (from port 0) during cycle 174 (1740ns - 1750ns)
*	Reading 0+00011100111111100011111010111100 from address 00000 (from port 0) during cycle 175 (1750ns - 1760ns)
*	Writing 0+10001010111110111011010001101001  to  address 00000 (from port 0) during cycle 176 (1760ns - 1770ns)
*	Writing 0+01011010111111011111011101111011  to  address 01111 (from port 0) during cycle 177 (1770ns - 1780ns)
*	Reading 0+01011010111111011111011101111011 from address 01111 (from port 0) during cycle 179 (1790ns - 1800ns)
*	Reading 0+10001010111110111011010001101001 from address 00000 (from port 0) during cycle 181 (1810ns - 1820ns)
*	Reading 0+01011010111111011111011101111011 from address 01111 (from port 0) during cycle 182 (1820ns - 1830ns)
*	Reading 0+10001010111110111011010001101001 from address 00000 (from port 0) during cycle 183 (1830ns - 1840ns)
*	Reading 0+10001010111110111011010001101001 from address 00000 (from port 0) during cycle 184 (1840ns - 1850ns)
*	Reading 0+10001010111110111011010001101001 from address 00000 (from port 0) during cycle 185 (1850ns - 1860ns)
*	Reading 0+01011010111111011111011101111011 from address 01111 (from port 0) during cycle 186 (1860ns - 1870ns)
*	Writing 0+01101001100111101001010110100011  to  address 00000 (from port 0) during cycle 189 (1890ns - 1900ns)
*	Writing 0+11011010011010000000110110001000  to  address 01111 (from port 0) during cycle 190 (1900ns - 1910ns)
*	Reading 0+11011010011010000000110110001000 from address 01111 (from port 0) during cycle 191 (1910ns - 1920ns)
*	Reading 0+11011010011010000000110110001000 from address 01111 (from port 0) during cycle 192 (1920ns - 1930ns)
*	Reading 0+01101001100111101001010110100011 from address 00000 (from port 0) during cycle 194 (1940ns - 1950ns)
*	Reading 0+11011010011010000000110110001000 from address 01111 (from port 0) during cycle 197 (1970ns - 1980ns)
*	Reading 0+11011010011010000000110110001000 from address 01111 (from port 0) during cycle 198 (1980ns - 1990ns)
*	Writing 0+10000011111101111000011010010100  to  address 00000 (from port 0) during cycle 199 (1990ns - 2000ns)
*	Reading 0+11011010011010000000110110001000 from address 01111 (from port 0) during cycle 202 (2020ns - 2030ns)
*	Writing 0+11111010100110000100101110010100  to  address 00000 (from port 0) during cycle 204 (2040ns - 2050ns)
*	Idle during cycle 205 (2050ns - 2060ns)

* Generation of data and address signals
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 1), (800, 1), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 1), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 0), (800, 1), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 1), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 0), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 1), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 1), (100, 1), (110, 1), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 0), (800, 1), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 0), (100, 0), (110, 0), (120, 1), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 1), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 1), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 0), (800, 1), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 1), (140, 1), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 1), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 1), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 0), (800, 1), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 0), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 0), (320, 1), (330, 0), (340, 1), (350, 0), (360, 0), (370, 0), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 0), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 1), (830, 0), (840, 0), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 0), (1030, 1), (1040, 0), (1050, 0), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 0), (1280, 1), (1290, 0), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 0), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 0), (320, 1), (330, 0), (340, 1), (350, 0), (360, 0), (370, 0), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 0), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 1), (830, 0), (840, 0), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 0), (1030, 1), (1040, 0), (1050, 0), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 0), (1280, 1), (1290, 0), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 0), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 0), (320, 1), (330, 0), (340, 1), (350, 0), (360, 0), (370, 0), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 0), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 1), (830, 0), (840, 0), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 0), (1030, 1), (1040, 0), (1050, 0), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 0), (1280, 1), (1290, 0), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 0), (120, 1), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 0), (320, 1), (330, 0), (340, 1), (350, 0), (360, 0), (370, 0), (380, 1), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 1), (480, 1), (490, 1), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 0), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 1), (830, 0), (840, 0), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 0), (1030, 1), (1040, 0), (1050, 0), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 0), (1280, 1), (1290, 0), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 0), (160, 0), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 0), (240, 1), (250, 0), (260, 0), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 1), (370, 1), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 0), (510, 0), (520, 1), (530, 1), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 0), (880, 0), (890, 1), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 0), (1340, 1), (1350, 0), (1360, 1), (1370, 0), (1380, 1), (1390, 0), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 0), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 0), (2030, 1), (2040, 0), (2050, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 1.8v )
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 0), (490, 1), (500, 1), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 1), (590, 0), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 1), (720, 0), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 0), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 0), (1220, 1), (1230, 1), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 1), (1660, 1), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 1), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 1.8v )

* Generation of spare enable signals
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
VSPARE_WEN0_0  SPARE_WEN0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* PULSE: period=10
Vclk0 clk0 0 PULSE (0 1.8 9.995n 0.01n 0.01n 4.99n 10n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 0 time = 50
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=50.05n

* CHECK dout0_1 Vdout0_1ck4 = 1.8 time = 50
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=50.05n

* CHECK dout0_2 Vdout0_2ck4 = 1.8 time = 50
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=50.05n

* CHECK dout0_3 Vdout0_3ck4 = 0 time = 50
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=50.05n

* CHECK dout0_4 Vdout0_4ck4 = 0 time = 50
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=50.05n

* CHECK dout0_5 Vdout0_5ck4 = 0 time = 50
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=50.05n

* CHECK dout0_6 Vdout0_6ck4 = 1.8 time = 50
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=50.05n

* CHECK dout0_7 Vdout0_7ck4 = 0 time = 50
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=50.05n

* CHECK dout0_8 Vdout0_8ck4 = 0 time = 50
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=50.05n

* CHECK dout0_9 Vdout0_9ck4 = 0 time = 50
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=50.05n

* CHECK dout0_10 Vdout0_10ck4 = 1.8 time = 50
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=50.05n

* CHECK dout0_11 Vdout0_11ck4 = 0 time = 50
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=50.05n

* CHECK dout0_12 Vdout0_12ck4 = 0 time = 50
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=50.05n

* CHECK dout0_13 Vdout0_13ck4 = 1.8 time = 50
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=50.05n

* CHECK dout0_14 Vdout0_14ck4 = 0 time = 50
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=50.05n

* CHECK dout0_15 Vdout0_15ck4 = 0 time = 50
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=50.05n

* CHECK dout0_16 Vdout0_16ck4 = 1.8 time = 50
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=50.05n

* CHECK dout0_17 Vdout0_17ck4 = 0 time = 50
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=50.05n

* CHECK dout0_18 Vdout0_18ck4 = 1.8 time = 50
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=50.05n

* CHECK dout0_19 Vdout0_19ck4 = 1.8 time = 50
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=50.05n

* CHECK dout0_20 Vdout0_20ck4 = 1.8 time = 50
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=50.05n

* CHECK dout0_21 Vdout0_21ck4 = 0 time = 50
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=50.05n

* CHECK dout0_22 Vdout0_22ck4 = 1.8 time = 50
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=50.05n

* CHECK dout0_23 Vdout0_23ck4 = 0 time = 50
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=50.05n

* CHECK dout0_24 Vdout0_24ck4 = 0 time = 50
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=50.05n

* CHECK dout0_25 Vdout0_25ck4 = 0 time = 50
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=50.05n

* CHECK dout0_26 Vdout0_26ck4 = 0 time = 50
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=50.05n

* CHECK dout0_27 Vdout0_27ck4 = 1.8 time = 50
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=50.05n

* CHECK dout0_28 Vdout0_28ck4 = 1.8 time = 50
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=50.05n

* CHECK dout0_29 Vdout0_29ck4 = 1.8 time = 50
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=50.05n

* CHECK dout0_30 Vdout0_30ck4 = 0 time = 50
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=50.05n

* CHECK dout0_31 Vdout0_31ck4 = 1.8 time = 50
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=50.05n

* CHECK dout0_32 Vdout0_32ck4 = 0 time = 50
.meas tran vdout0_32ck4 FIND v(dout0_32) AT=50.05n

* CHECK dout0_0 Vdout0_0ck5 = 0 time = 60
.meas tran vdout0_0ck5 FIND v(dout0_0) AT=60.05n

* CHECK dout0_1 Vdout0_1ck5 = 1.8 time = 60
.meas tran vdout0_1ck5 FIND v(dout0_1) AT=60.05n

* CHECK dout0_2 Vdout0_2ck5 = 1.8 time = 60
.meas tran vdout0_2ck5 FIND v(dout0_2) AT=60.05n

* CHECK dout0_3 Vdout0_3ck5 = 0 time = 60
.meas tran vdout0_3ck5 FIND v(dout0_3) AT=60.05n

* CHECK dout0_4 Vdout0_4ck5 = 0 time = 60
.meas tran vdout0_4ck5 FIND v(dout0_4) AT=60.05n

* CHECK dout0_5 Vdout0_5ck5 = 0 time = 60
.meas tran vdout0_5ck5 FIND v(dout0_5) AT=60.05n

* CHECK dout0_6 Vdout0_6ck5 = 1.8 time = 60
.meas tran vdout0_6ck5 FIND v(dout0_6) AT=60.05n

* CHECK dout0_7 Vdout0_7ck5 = 0 time = 60
.meas tran vdout0_7ck5 FIND v(dout0_7) AT=60.05n

* CHECK dout0_8 Vdout0_8ck5 = 0 time = 60
.meas tran vdout0_8ck5 FIND v(dout0_8) AT=60.05n

* CHECK dout0_9 Vdout0_9ck5 = 0 time = 60
.meas tran vdout0_9ck5 FIND v(dout0_9) AT=60.05n

* CHECK dout0_10 Vdout0_10ck5 = 1.8 time = 60
.meas tran vdout0_10ck5 FIND v(dout0_10) AT=60.05n

* CHECK dout0_11 Vdout0_11ck5 = 0 time = 60
.meas tran vdout0_11ck5 FIND v(dout0_11) AT=60.05n

* CHECK dout0_12 Vdout0_12ck5 = 0 time = 60
.meas tran vdout0_12ck5 FIND v(dout0_12) AT=60.05n

* CHECK dout0_13 Vdout0_13ck5 = 1.8 time = 60
.meas tran vdout0_13ck5 FIND v(dout0_13) AT=60.05n

* CHECK dout0_14 Vdout0_14ck5 = 0 time = 60
.meas tran vdout0_14ck5 FIND v(dout0_14) AT=60.05n

* CHECK dout0_15 Vdout0_15ck5 = 0 time = 60
.meas tran vdout0_15ck5 FIND v(dout0_15) AT=60.05n

* CHECK dout0_16 Vdout0_16ck5 = 1.8 time = 60
.meas tran vdout0_16ck5 FIND v(dout0_16) AT=60.05n

* CHECK dout0_17 Vdout0_17ck5 = 0 time = 60
.meas tran vdout0_17ck5 FIND v(dout0_17) AT=60.05n

* CHECK dout0_18 Vdout0_18ck5 = 1.8 time = 60
.meas tran vdout0_18ck5 FIND v(dout0_18) AT=60.05n

* CHECK dout0_19 Vdout0_19ck5 = 1.8 time = 60
.meas tran vdout0_19ck5 FIND v(dout0_19) AT=60.05n

* CHECK dout0_20 Vdout0_20ck5 = 1.8 time = 60
.meas tran vdout0_20ck5 FIND v(dout0_20) AT=60.05n

* CHECK dout0_21 Vdout0_21ck5 = 0 time = 60
.meas tran vdout0_21ck5 FIND v(dout0_21) AT=60.05n

* CHECK dout0_22 Vdout0_22ck5 = 1.8 time = 60
.meas tran vdout0_22ck5 FIND v(dout0_22) AT=60.05n

* CHECK dout0_23 Vdout0_23ck5 = 0 time = 60
.meas tran vdout0_23ck5 FIND v(dout0_23) AT=60.05n

* CHECK dout0_24 Vdout0_24ck5 = 0 time = 60
.meas tran vdout0_24ck5 FIND v(dout0_24) AT=60.05n

* CHECK dout0_25 Vdout0_25ck5 = 0 time = 60
.meas tran vdout0_25ck5 FIND v(dout0_25) AT=60.05n

* CHECK dout0_26 Vdout0_26ck5 = 0 time = 60
.meas tran vdout0_26ck5 FIND v(dout0_26) AT=60.05n

* CHECK dout0_27 Vdout0_27ck5 = 1.8 time = 60
.meas tran vdout0_27ck5 FIND v(dout0_27) AT=60.05n

* CHECK dout0_28 Vdout0_28ck5 = 1.8 time = 60
.meas tran vdout0_28ck5 FIND v(dout0_28) AT=60.05n

* CHECK dout0_29 Vdout0_29ck5 = 1.8 time = 60
.meas tran vdout0_29ck5 FIND v(dout0_29) AT=60.05n

* CHECK dout0_30 Vdout0_30ck5 = 0 time = 60
.meas tran vdout0_30ck5 FIND v(dout0_30) AT=60.05n

* CHECK dout0_31 Vdout0_31ck5 = 1.8 time = 60
.meas tran vdout0_31ck5 FIND v(dout0_31) AT=60.05n

* CHECK dout0_32 Vdout0_32ck5 = 0 time = 60
.meas tran vdout0_32ck5 FIND v(dout0_32) AT=60.05n

* CHECK dout0_0 Vdout0_0ck6 = 0 time = 70
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=70.05n

* CHECK dout0_1 Vdout0_1ck6 = 1.8 time = 70
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=70.05n

* CHECK dout0_2 Vdout0_2ck6 = 1.8 time = 70
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=70.05n

* CHECK dout0_3 Vdout0_3ck6 = 0 time = 70
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=70.05n

* CHECK dout0_4 Vdout0_4ck6 = 0 time = 70
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=70.05n

* CHECK dout0_5 Vdout0_5ck6 = 0 time = 70
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=70.05n

* CHECK dout0_6 Vdout0_6ck6 = 1.8 time = 70
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=70.05n

* CHECK dout0_7 Vdout0_7ck6 = 0 time = 70
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=70.05n

* CHECK dout0_8 Vdout0_8ck6 = 0 time = 70
.meas tran vdout0_8ck6 FIND v(dout0_8) AT=70.05n

* CHECK dout0_9 Vdout0_9ck6 = 0 time = 70
.meas tran vdout0_9ck6 FIND v(dout0_9) AT=70.05n

* CHECK dout0_10 Vdout0_10ck6 = 1.8 time = 70
.meas tran vdout0_10ck6 FIND v(dout0_10) AT=70.05n

* CHECK dout0_11 Vdout0_11ck6 = 0 time = 70
.meas tran vdout0_11ck6 FIND v(dout0_11) AT=70.05n

* CHECK dout0_12 Vdout0_12ck6 = 0 time = 70
.meas tran vdout0_12ck6 FIND v(dout0_12) AT=70.05n

* CHECK dout0_13 Vdout0_13ck6 = 1.8 time = 70
.meas tran vdout0_13ck6 FIND v(dout0_13) AT=70.05n

* CHECK dout0_14 Vdout0_14ck6 = 0 time = 70
.meas tran vdout0_14ck6 FIND v(dout0_14) AT=70.05n

* CHECK dout0_15 Vdout0_15ck6 = 0 time = 70
.meas tran vdout0_15ck6 FIND v(dout0_15) AT=70.05n

* CHECK dout0_16 Vdout0_16ck6 = 1.8 time = 70
.meas tran vdout0_16ck6 FIND v(dout0_16) AT=70.05n

* CHECK dout0_17 Vdout0_17ck6 = 0 time = 70
.meas tran vdout0_17ck6 FIND v(dout0_17) AT=70.05n

* CHECK dout0_18 Vdout0_18ck6 = 1.8 time = 70
.meas tran vdout0_18ck6 FIND v(dout0_18) AT=70.05n

* CHECK dout0_19 Vdout0_19ck6 = 1.8 time = 70
.meas tran vdout0_19ck6 FIND v(dout0_19) AT=70.05n

* CHECK dout0_20 Vdout0_20ck6 = 1.8 time = 70
.meas tran vdout0_20ck6 FIND v(dout0_20) AT=70.05n

* CHECK dout0_21 Vdout0_21ck6 = 0 time = 70
.meas tran vdout0_21ck6 FIND v(dout0_21) AT=70.05n

* CHECK dout0_22 Vdout0_22ck6 = 1.8 time = 70
.meas tran vdout0_22ck6 FIND v(dout0_22) AT=70.05n

* CHECK dout0_23 Vdout0_23ck6 = 0 time = 70
.meas tran vdout0_23ck6 FIND v(dout0_23) AT=70.05n

* CHECK dout0_24 Vdout0_24ck6 = 0 time = 70
.meas tran vdout0_24ck6 FIND v(dout0_24) AT=70.05n

* CHECK dout0_25 Vdout0_25ck6 = 0 time = 70
.meas tran vdout0_25ck6 FIND v(dout0_25) AT=70.05n

* CHECK dout0_26 Vdout0_26ck6 = 0 time = 70
.meas tran vdout0_26ck6 FIND v(dout0_26) AT=70.05n

* CHECK dout0_27 Vdout0_27ck6 = 1.8 time = 70
.meas tran vdout0_27ck6 FIND v(dout0_27) AT=70.05n

* CHECK dout0_28 Vdout0_28ck6 = 1.8 time = 70
.meas tran vdout0_28ck6 FIND v(dout0_28) AT=70.05n

* CHECK dout0_29 Vdout0_29ck6 = 1.8 time = 70
.meas tran vdout0_29ck6 FIND v(dout0_29) AT=70.05n

* CHECK dout0_30 Vdout0_30ck6 = 0 time = 70
.meas tran vdout0_30ck6 FIND v(dout0_30) AT=70.05n

* CHECK dout0_31 Vdout0_31ck6 = 1.8 time = 70
.meas tran vdout0_31ck6 FIND v(dout0_31) AT=70.05n

* CHECK dout0_32 Vdout0_32ck6 = 0 time = 70
.meas tran vdout0_32ck6 FIND v(dout0_32) AT=70.05n

* CHECK dout0_0 Vdout0_0ck10 = 1.8 time = 110
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=110.05n

* CHECK dout0_1 Vdout0_1ck10 = 1.8 time = 110
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=110.05n

* CHECK dout0_2 Vdout0_2ck10 = 0 time = 110
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=110.05n

* CHECK dout0_3 Vdout0_3ck10 = 0 time = 110
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=110.05n

* CHECK dout0_4 Vdout0_4ck10 = 1.8 time = 110
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=110.05n

* CHECK dout0_5 Vdout0_5ck10 = 1.8 time = 110
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=110.05n

* CHECK dout0_6 Vdout0_6ck10 = 1.8 time = 110
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=110.05n

* CHECK dout0_7 Vdout0_7ck10 = 0 time = 110
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=110.05n

* CHECK dout0_8 Vdout0_8ck10 = 1.8 time = 110
.meas tran vdout0_8ck10 FIND v(dout0_8) AT=110.05n

* CHECK dout0_9 Vdout0_9ck10 = 1.8 time = 110
.meas tran vdout0_9ck10 FIND v(dout0_9) AT=110.05n

* CHECK dout0_10 Vdout0_10ck10 = 0 time = 110
.meas tran vdout0_10ck10 FIND v(dout0_10) AT=110.05n

* CHECK dout0_11 Vdout0_11ck10 = 0 time = 110
.meas tran vdout0_11ck10 FIND v(dout0_11) AT=110.05n

* CHECK dout0_12 Vdout0_12ck10 = 1.8 time = 110
.meas tran vdout0_12ck10 FIND v(dout0_12) AT=110.05n

* CHECK dout0_13 Vdout0_13ck10 = 1.8 time = 110
.meas tran vdout0_13ck10 FIND v(dout0_13) AT=110.05n

* CHECK dout0_14 Vdout0_14ck10 = 1.8 time = 110
.meas tran vdout0_14ck10 FIND v(dout0_14) AT=110.05n

* CHECK dout0_15 Vdout0_15ck10 = 0 time = 110
.meas tran vdout0_15ck10 FIND v(dout0_15) AT=110.05n

* CHECK dout0_16 Vdout0_16ck10 = 1.8 time = 110
.meas tran vdout0_16ck10 FIND v(dout0_16) AT=110.05n

* CHECK dout0_17 Vdout0_17ck10 = 0 time = 110
.meas tran vdout0_17ck10 FIND v(dout0_17) AT=110.05n

* CHECK dout0_18 Vdout0_18ck10 = 1.8 time = 110
.meas tran vdout0_18ck10 FIND v(dout0_18) AT=110.05n

* CHECK dout0_19 Vdout0_19ck10 = 0 time = 110
.meas tran vdout0_19ck10 FIND v(dout0_19) AT=110.05n

* CHECK dout0_20 Vdout0_20ck10 = 1.8 time = 110
.meas tran vdout0_20ck10 FIND v(dout0_20) AT=110.05n

* CHECK dout0_21 Vdout0_21ck10 = 1.8 time = 110
.meas tran vdout0_21ck10 FIND v(dout0_21) AT=110.05n

* CHECK dout0_22 Vdout0_22ck10 = 1.8 time = 110
.meas tran vdout0_22ck10 FIND v(dout0_22) AT=110.05n

* CHECK dout0_23 Vdout0_23ck10 = 0 time = 110
.meas tran vdout0_23ck10 FIND v(dout0_23) AT=110.05n

* CHECK dout0_24 Vdout0_24ck10 = 1.8 time = 110
.meas tran vdout0_24ck10 FIND v(dout0_24) AT=110.05n

* CHECK dout0_25 Vdout0_25ck10 = 1.8 time = 110
.meas tran vdout0_25ck10 FIND v(dout0_25) AT=110.05n

* CHECK dout0_26 Vdout0_26ck10 = 1.8 time = 110
.meas tran vdout0_26ck10 FIND v(dout0_26) AT=110.05n

* CHECK dout0_27 Vdout0_27ck10 = 0 time = 110
.meas tran vdout0_27ck10 FIND v(dout0_27) AT=110.05n

* CHECK dout0_28 Vdout0_28ck10 = 0 time = 110
.meas tran vdout0_28ck10 FIND v(dout0_28) AT=110.05n

* CHECK dout0_29 Vdout0_29ck10 = 1.8 time = 110
.meas tran vdout0_29ck10 FIND v(dout0_29) AT=110.05n

* CHECK dout0_30 Vdout0_30ck10 = 0 time = 110
.meas tran vdout0_30ck10 FIND v(dout0_30) AT=110.05n

* CHECK dout0_31 Vdout0_31ck10 = 1.8 time = 110
.meas tran vdout0_31ck10 FIND v(dout0_31) AT=110.05n

* CHECK dout0_32 Vdout0_32ck10 = 0 time = 110
.meas tran vdout0_32ck10 FIND v(dout0_32) AT=110.05n

* CHECK dout0_0 Vdout0_0ck11 = 0 time = 120
.meas tran vdout0_0ck11 FIND v(dout0_0) AT=120.05n

* CHECK dout0_1 Vdout0_1ck11 = 1.8 time = 120
.meas tran vdout0_1ck11 FIND v(dout0_1) AT=120.05n

* CHECK dout0_2 Vdout0_2ck11 = 1.8 time = 120
.meas tran vdout0_2ck11 FIND v(dout0_2) AT=120.05n

* CHECK dout0_3 Vdout0_3ck11 = 0 time = 120
.meas tran vdout0_3ck11 FIND v(dout0_3) AT=120.05n

* CHECK dout0_4 Vdout0_4ck11 = 0 time = 120
.meas tran vdout0_4ck11 FIND v(dout0_4) AT=120.05n

* CHECK dout0_5 Vdout0_5ck11 = 0 time = 120
.meas tran vdout0_5ck11 FIND v(dout0_5) AT=120.05n

* CHECK dout0_6 Vdout0_6ck11 = 1.8 time = 120
.meas tran vdout0_6ck11 FIND v(dout0_6) AT=120.05n

* CHECK dout0_7 Vdout0_7ck11 = 0 time = 120
.meas tran vdout0_7ck11 FIND v(dout0_7) AT=120.05n

* CHECK dout0_8 Vdout0_8ck11 = 0 time = 120
.meas tran vdout0_8ck11 FIND v(dout0_8) AT=120.05n

* CHECK dout0_9 Vdout0_9ck11 = 0 time = 120
.meas tran vdout0_9ck11 FIND v(dout0_9) AT=120.05n

* CHECK dout0_10 Vdout0_10ck11 = 1.8 time = 120
.meas tran vdout0_10ck11 FIND v(dout0_10) AT=120.05n

* CHECK dout0_11 Vdout0_11ck11 = 0 time = 120
.meas tran vdout0_11ck11 FIND v(dout0_11) AT=120.05n

* CHECK dout0_12 Vdout0_12ck11 = 0 time = 120
.meas tran vdout0_12ck11 FIND v(dout0_12) AT=120.05n

* CHECK dout0_13 Vdout0_13ck11 = 1.8 time = 120
.meas tran vdout0_13ck11 FIND v(dout0_13) AT=120.05n

* CHECK dout0_14 Vdout0_14ck11 = 0 time = 120
.meas tran vdout0_14ck11 FIND v(dout0_14) AT=120.05n

* CHECK dout0_15 Vdout0_15ck11 = 0 time = 120
.meas tran vdout0_15ck11 FIND v(dout0_15) AT=120.05n

* CHECK dout0_16 Vdout0_16ck11 = 1.8 time = 120
.meas tran vdout0_16ck11 FIND v(dout0_16) AT=120.05n

* CHECK dout0_17 Vdout0_17ck11 = 0 time = 120
.meas tran vdout0_17ck11 FIND v(dout0_17) AT=120.05n

* CHECK dout0_18 Vdout0_18ck11 = 1.8 time = 120
.meas tran vdout0_18ck11 FIND v(dout0_18) AT=120.05n

* CHECK dout0_19 Vdout0_19ck11 = 1.8 time = 120
.meas tran vdout0_19ck11 FIND v(dout0_19) AT=120.05n

* CHECK dout0_20 Vdout0_20ck11 = 1.8 time = 120
.meas tran vdout0_20ck11 FIND v(dout0_20) AT=120.05n

* CHECK dout0_21 Vdout0_21ck11 = 0 time = 120
.meas tran vdout0_21ck11 FIND v(dout0_21) AT=120.05n

* CHECK dout0_22 Vdout0_22ck11 = 1.8 time = 120
.meas tran vdout0_22ck11 FIND v(dout0_22) AT=120.05n

* CHECK dout0_23 Vdout0_23ck11 = 0 time = 120
.meas tran vdout0_23ck11 FIND v(dout0_23) AT=120.05n

* CHECK dout0_24 Vdout0_24ck11 = 0 time = 120
.meas tran vdout0_24ck11 FIND v(dout0_24) AT=120.05n

* CHECK dout0_25 Vdout0_25ck11 = 0 time = 120
.meas tran vdout0_25ck11 FIND v(dout0_25) AT=120.05n

* CHECK dout0_26 Vdout0_26ck11 = 0 time = 120
.meas tran vdout0_26ck11 FIND v(dout0_26) AT=120.05n

* CHECK dout0_27 Vdout0_27ck11 = 1.8 time = 120
.meas tran vdout0_27ck11 FIND v(dout0_27) AT=120.05n

* CHECK dout0_28 Vdout0_28ck11 = 1.8 time = 120
.meas tran vdout0_28ck11 FIND v(dout0_28) AT=120.05n

* CHECK dout0_29 Vdout0_29ck11 = 1.8 time = 120
.meas tran vdout0_29ck11 FIND v(dout0_29) AT=120.05n

* CHECK dout0_30 Vdout0_30ck11 = 0 time = 120
.meas tran vdout0_30ck11 FIND v(dout0_30) AT=120.05n

* CHECK dout0_31 Vdout0_31ck11 = 1.8 time = 120
.meas tran vdout0_31ck11 FIND v(dout0_31) AT=120.05n

* CHECK dout0_32 Vdout0_32ck11 = 0 time = 120
.meas tran vdout0_32ck11 FIND v(dout0_32) AT=120.05n

* CHECK dout0_0 Vdout0_0ck16 = 0 time = 170
.meas tran vdout0_0ck16 FIND v(dout0_0) AT=170.05n

* CHECK dout0_1 Vdout0_1ck16 = 0 time = 170
.meas tran vdout0_1ck16 FIND v(dout0_1) AT=170.05n

* CHECK dout0_2 Vdout0_2ck16 = 0 time = 170
.meas tran vdout0_2ck16 FIND v(dout0_2) AT=170.05n

* CHECK dout0_3 Vdout0_3ck16 = 1.8 time = 170
.meas tran vdout0_3ck16 FIND v(dout0_3) AT=170.05n

* CHECK dout0_4 Vdout0_4ck16 = 1.8 time = 170
.meas tran vdout0_4ck16 FIND v(dout0_4) AT=170.05n

* CHECK dout0_5 Vdout0_5ck16 = 1.8 time = 170
.meas tran vdout0_5ck16 FIND v(dout0_5) AT=170.05n

* CHECK dout0_6 Vdout0_6ck16 = 0 time = 170
.meas tran vdout0_6ck16 FIND v(dout0_6) AT=170.05n

* CHECK dout0_7 Vdout0_7ck16 = 0 time = 170
.meas tran vdout0_7ck16 FIND v(dout0_7) AT=170.05n

* CHECK dout0_8 Vdout0_8ck16 = 1.8 time = 170
.meas tran vdout0_8ck16 FIND v(dout0_8) AT=170.05n

* CHECK dout0_9 Vdout0_9ck16 = 0 time = 170
.meas tran vdout0_9ck16 FIND v(dout0_9) AT=170.05n

* CHECK dout0_10 Vdout0_10ck16 = 1.8 time = 170
.meas tran vdout0_10ck16 FIND v(dout0_10) AT=170.05n

* CHECK dout0_11 Vdout0_11ck16 = 1.8 time = 170
.meas tran vdout0_11ck16 FIND v(dout0_11) AT=170.05n

* CHECK dout0_12 Vdout0_12ck16 = 0 time = 170
.meas tran vdout0_12ck16 FIND v(dout0_12) AT=170.05n

* CHECK dout0_13 Vdout0_13ck16 = 0 time = 170
.meas tran vdout0_13ck16 FIND v(dout0_13) AT=170.05n

* CHECK dout0_14 Vdout0_14ck16 = 1.8 time = 170
.meas tran vdout0_14ck16 FIND v(dout0_14) AT=170.05n

* CHECK dout0_15 Vdout0_15ck16 = 1.8 time = 170
.meas tran vdout0_15ck16 FIND v(dout0_15) AT=170.05n

* CHECK dout0_16 Vdout0_16ck16 = 1.8 time = 170
.meas tran vdout0_16ck16 FIND v(dout0_16) AT=170.05n

* CHECK dout0_17 Vdout0_17ck16 = 0 time = 170
.meas tran vdout0_17ck16 FIND v(dout0_17) AT=170.05n

* CHECK dout0_18 Vdout0_18ck16 = 0 time = 170
.meas tran vdout0_18ck16 FIND v(dout0_18) AT=170.05n

* CHECK dout0_19 Vdout0_19ck16 = 0 time = 170
.meas tran vdout0_19ck16 FIND v(dout0_19) AT=170.05n

* CHECK dout0_20 Vdout0_20ck16 = 1.8 time = 170
.meas tran vdout0_20ck16 FIND v(dout0_20) AT=170.05n

* CHECK dout0_21 Vdout0_21ck16 = 0 time = 170
.meas tran vdout0_21ck16 FIND v(dout0_21) AT=170.05n

* CHECK dout0_22 Vdout0_22ck16 = 0 time = 170
.meas tran vdout0_22ck16 FIND v(dout0_22) AT=170.05n

* CHECK dout0_23 Vdout0_23ck16 = 1.8 time = 170
.meas tran vdout0_23ck16 FIND v(dout0_23) AT=170.05n

* CHECK dout0_24 Vdout0_24ck16 = 1.8 time = 170
.meas tran vdout0_24ck16 FIND v(dout0_24) AT=170.05n

* CHECK dout0_25 Vdout0_25ck16 = 1.8 time = 170
.meas tran vdout0_25ck16 FIND v(dout0_25) AT=170.05n

* CHECK dout0_26 Vdout0_26ck16 = 1.8 time = 170
.meas tran vdout0_26ck16 FIND v(dout0_26) AT=170.05n

* CHECK dout0_27 Vdout0_27ck16 = 0 time = 170
.meas tran vdout0_27ck16 FIND v(dout0_27) AT=170.05n

* CHECK dout0_28 Vdout0_28ck16 = 1.8 time = 170
.meas tran vdout0_28ck16 FIND v(dout0_28) AT=170.05n

* CHECK dout0_29 Vdout0_29ck16 = 0 time = 170
.meas tran vdout0_29ck16 FIND v(dout0_29) AT=170.05n

* CHECK dout0_30 Vdout0_30ck16 = 0 time = 170
.meas tran vdout0_30ck16 FIND v(dout0_30) AT=170.05n

* CHECK dout0_31 Vdout0_31ck16 = 0 time = 170
.meas tran vdout0_31ck16 FIND v(dout0_31) AT=170.05n

* CHECK dout0_32 Vdout0_32ck16 = 0 time = 170
.meas tran vdout0_32ck16 FIND v(dout0_32) AT=170.05n

* CHECK dout0_0 Vdout0_0ck18 = 0 time = 190
.meas tran vdout0_0ck18 FIND v(dout0_0) AT=190.05n

* CHECK dout0_1 Vdout0_1ck18 = 0 time = 190
.meas tran vdout0_1ck18 FIND v(dout0_1) AT=190.05n

* CHECK dout0_2 Vdout0_2ck18 = 0 time = 190
.meas tran vdout0_2ck18 FIND v(dout0_2) AT=190.05n

* CHECK dout0_3 Vdout0_3ck18 = 1.8 time = 190
.meas tran vdout0_3ck18 FIND v(dout0_3) AT=190.05n

* CHECK dout0_4 Vdout0_4ck18 = 1.8 time = 190
.meas tran vdout0_4ck18 FIND v(dout0_4) AT=190.05n

* CHECK dout0_5 Vdout0_5ck18 = 1.8 time = 190
.meas tran vdout0_5ck18 FIND v(dout0_5) AT=190.05n

* CHECK dout0_6 Vdout0_6ck18 = 0 time = 190
.meas tran vdout0_6ck18 FIND v(dout0_6) AT=190.05n

* CHECK dout0_7 Vdout0_7ck18 = 0 time = 190
.meas tran vdout0_7ck18 FIND v(dout0_7) AT=190.05n

* CHECK dout0_8 Vdout0_8ck18 = 1.8 time = 190
.meas tran vdout0_8ck18 FIND v(dout0_8) AT=190.05n

* CHECK dout0_9 Vdout0_9ck18 = 0 time = 190
.meas tran vdout0_9ck18 FIND v(dout0_9) AT=190.05n

* CHECK dout0_10 Vdout0_10ck18 = 1.8 time = 190
.meas tran vdout0_10ck18 FIND v(dout0_10) AT=190.05n

* CHECK dout0_11 Vdout0_11ck18 = 1.8 time = 190
.meas tran vdout0_11ck18 FIND v(dout0_11) AT=190.05n

* CHECK dout0_12 Vdout0_12ck18 = 0 time = 190
.meas tran vdout0_12ck18 FIND v(dout0_12) AT=190.05n

* CHECK dout0_13 Vdout0_13ck18 = 0 time = 190
.meas tran vdout0_13ck18 FIND v(dout0_13) AT=190.05n

* CHECK dout0_14 Vdout0_14ck18 = 1.8 time = 190
.meas tran vdout0_14ck18 FIND v(dout0_14) AT=190.05n

* CHECK dout0_15 Vdout0_15ck18 = 1.8 time = 190
.meas tran vdout0_15ck18 FIND v(dout0_15) AT=190.05n

* CHECK dout0_16 Vdout0_16ck18 = 1.8 time = 190
.meas tran vdout0_16ck18 FIND v(dout0_16) AT=190.05n

* CHECK dout0_17 Vdout0_17ck18 = 0 time = 190
.meas tran vdout0_17ck18 FIND v(dout0_17) AT=190.05n

* CHECK dout0_18 Vdout0_18ck18 = 0 time = 190
.meas tran vdout0_18ck18 FIND v(dout0_18) AT=190.05n

* CHECK dout0_19 Vdout0_19ck18 = 0 time = 190
.meas tran vdout0_19ck18 FIND v(dout0_19) AT=190.05n

* CHECK dout0_20 Vdout0_20ck18 = 1.8 time = 190
.meas tran vdout0_20ck18 FIND v(dout0_20) AT=190.05n

* CHECK dout0_21 Vdout0_21ck18 = 0 time = 190
.meas tran vdout0_21ck18 FIND v(dout0_21) AT=190.05n

* CHECK dout0_22 Vdout0_22ck18 = 0 time = 190
.meas tran vdout0_22ck18 FIND v(dout0_22) AT=190.05n

* CHECK dout0_23 Vdout0_23ck18 = 1.8 time = 190
.meas tran vdout0_23ck18 FIND v(dout0_23) AT=190.05n

* CHECK dout0_24 Vdout0_24ck18 = 1.8 time = 190
.meas tran vdout0_24ck18 FIND v(dout0_24) AT=190.05n

* CHECK dout0_25 Vdout0_25ck18 = 1.8 time = 190
.meas tran vdout0_25ck18 FIND v(dout0_25) AT=190.05n

* CHECK dout0_26 Vdout0_26ck18 = 1.8 time = 190
.meas tran vdout0_26ck18 FIND v(dout0_26) AT=190.05n

* CHECK dout0_27 Vdout0_27ck18 = 0 time = 190
.meas tran vdout0_27ck18 FIND v(dout0_27) AT=190.05n

* CHECK dout0_28 Vdout0_28ck18 = 1.8 time = 190
.meas tran vdout0_28ck18 FIND v(dout0_28) AT=190.05n

* CHECK dout0_29 Vdout0_29ck18 = 0 time = 190
.meas tran vdout0_29ck18 FIND v(dout0_29) AT=190.05n

* CHECK dout0_30 Vdout0_30ck18 = 0 time = 190
.meas tran vdout0_30ck18 FIND v(dout0_30) AT=190.05n

* CHECK dout0_31 Vdout0_31ck18 = 0 time = 190
.meas tran vdout0_31ck18 FIND v(dout0_31) AT=190.05n

* CHECK dout0_32 Vdout0_32ck18 = 0 time = 190
.meas tran vdout0_32ck18 FIND v(dout0_32) AT=190.05n

* CHECK dout0_0 Vdout0_0ck19 = 0 time = 200
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=200.05n

* CHECK dout0_1 Vdout0_1ck19 = 0 time = 200
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=200.05n

* CHECK dout0_2 Vdout0_2ck19 = 0 time = 200
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=200.05n

* CHECK dout0_3 Vdout0_3ck19 = 1.8 time = 200
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=200.05n

* CHECK dout0_4 Vdout0_4ck19 = 1.8 time = 200
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=200.05n

* CHECK dout0_5 Vdout0_5ck19 = 1.8 time = 200
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=200.05n

* CHECK dout0_6 Vdout0_6ck19 = 0 time = 200
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=200.05n

* CHECK dout0_7 Vdout0_7ck19 = 0 time = 200
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=200.05n

* CHECK dout0_8 Vdout0_8ck19 = 1.8 time = 200
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=200.05n

* CHECK dout0_9 Vdout0_9ck19 = 0 time = 200
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=200.05n

* CHECK dout0_10 Vdout0_10ck19 = 1.8 time = 200
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=200.05n

* CHECK dout0_11 Vdout0_11ck19 = 1.8 time = 200
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=200.05n

* CHECK dout0_12 Vdout0_12ck19 = 0 time = 200
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=200.05n

* CHECK dout0_13 Vdout0_13ck19 = 0 time = 200
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=200.05n

* CHECK dout0_14 Vdout0_14ck19 = 1.8 time = 200
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=200.05n

* CHECK dout0_15 Vdout0_15ck19 = 1.8 time = 200
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=200.05n

* CHECK dout0_16 Vdout0_16ck19 = 1.8 time = 200
.meas tran vdout0_16ck19 FIND v(dout0_16) AT=200.05n

* CHECK dout0_17 Vdout0_17ck19 = 0 time = 200
.meas tran vdout0_17ck19 FIND v(dout0_17) AT=200.05n

* CHECK dout0_18 Vdout0_18ck19 = 0 time = 200
.meas tran vdout0_18ck19 FIND v(dout0_18) AT=200.05n

* CHECK dout0_19 Vdout0_19ck19 = 0 time = 200
.meas tran vdout0_19ck19 FIND v(dout0_19) AT=200.05n

* CHECK dout0_20 Vdout0_20ck19 = 1.8 time = 200
.meas tran vdout0_20ck19 FIND v(dout0_20) AT=200.05n

* CHECK dout0_21 Vdout0_21ck19 = 0 time = 200
.meas tran vdout0_21ck19 FIND v(dout0_21) AT=200.05n

* CHECK dout0_22 Vdout0_22ck19 = 0 time = 200
.meas tran vdout0_22ck19 FIND v(dout0_22) AT=200.05n

* CHECK dout0_23 Vdout0_23ck19 = 1.8 time = 200
.meas tran vdout0_23ck19 FIND v(dout0_23) AT=200.05n

* CHECK dout0_24 Vdout0_24ck19 = 1.8 time = 200
.meas tran vdout0_24ck19 FIND v(dout0_24) AT=200.05n

* CHECK dout0_25 Vdout0_25ck19 = 1.8 time = 200
.meas tran vdout0_25ck19 FIND v(dout0_25) AT=200.05n

* CHECK dout0_26 Vdout0_26ck19 = 1.8 time = 200
.meas tran vdout0_26ck19 FIND v(dout0_26) AT=200.05n

* CHECK dout0_27 Vdout0_27ck19 = 0 time = 200
.meas tran vdout0_27ck19 FIND v(dout0_27) AT=200.05n

* CHECK dout0_28 Vdout0_28ck19 = 1.8 time = 200
.meas tran vdout0_28ck19 FIND v(dout0_28) AT=200.05n

* CHECK dout0_29 Vdout0_29ck19 = 0 time = 200
.meas tran vdout0_29ck19 FIND v(dout0_29) AT=200.05n

* CHECK dout0_30 Vdout0_30ck19 = 0 time = 200
.meas tran vdout0_30ck19 FIND v(dout0_30) AT=200.05n

* CHECK dout0_31 Vdout0_31ck19 = 0 time = 200
.meas tran vdout0_31ck19 FIND v(dout0_31) AT=200.05n

* CHECK dout0_32 Vdout0_32ck19 = 0 time = 200
.meas tran vdout0_32ck19 FIND v(dout0_32) AT=200.05n

* CHECK dout0_0 Vdout0_0ck20 = 0 time = 210
.meas tran vdout0_0ck20 FIND v(dout0_0) AT=210.05n

* CHECK dout0_1 Vdout0_1ck20 = 0 time = 210
.meas tran vdout0_1ck20 FIND v(dout0_1) AT=210.05n

* CHECK dout0_2 Vdout0_2ck20 = 0 time = 210
.meas tran vdout0_2ck20 FIND v(dout0_2) AT=210.05n

* CHECK dout0_3 Vdout0_3ck20 = 1.8 time = 210
.meas tran vdout0_3ck20 FIND v(dout0_3) AT=210.05n

* CHECK dout0_4 Vdout0_4ck20 = 1.8 time = 210
.meas tran vdout0_4ck20 FIND v(dout0_4) AT=210.05n

* CHECK dout0_5 Vdout0_5ck20 = 1.8 time = 210
.meas tran vdout0_5ck20 FIND v(dout0_5) AT=210.05n

* CHECK dout0_6 Vdout0_6ck20 = 0 time = 210
.meas tran vdout0_6ck20 FIND v(dout0_6) AT=210.05n

* CHECK dout0_7 Vdout0_7ck20 = 0 time = 210
.meas tran vdout0_7ck20 FIND v(dout0_7) AT=210.05n

* CHECK dout0_8 Vdout0_8ck20 = 1.8 time = 210
.meas tran vdout0_8ck20 FIND v(dout0_8) AT=210.05n

* CHECK dout0_9 Vdout0_9ck20 = 0 time = 210
.meas tran vdout0_9ck20 FIND v(dout0_9) AT=210.05n

* CHECK dout0_10 Vdout0_10ck20 = 1.8 time = 210
.meas tran vdout0_10ck20 FIND v(dout0_10) AT=210.05n

* CHECK dout0_11 Vdout0_11ck20 = 1.8 time = 210
.meas tran vdout0_11ck20 FIND v(dout0_11) AT=210.05n

* CHECK dout0_12 Vdout0_12ck20 = 0 time = 210
.meas tran vdout0_12ck20 FIND v(dout0_12) AT=210.05n

* CHECK dout0_13 Vdout0_13ck20 = 0 time = 210
.meas tran vdout0_13ck20 FIND v(dout0_13) AT=210.05n

* CHECK dout0_14 Vdout0_14ck20 = 1.8 time = 210
.meas tran vdout0_14ck20 FIND v(dout0_14) AT=210.05n

* CHECK dout0_15 Vdout0_15ck20 = 1.8 time = 210
.meas tran vdout0_15ck20 FIND v(dout0_15) AT=210.05n

* CHECK dout0_16 Vdout0_16ck20 = 1.8 time = 210
.meas tran vdout0_16ck20 FIND v(dout0_16) AT=210.05n

* CHECK dout0_17 Vdout0_17ck20 = 0 time = 210
.meas tran vdout0_17ck20 FIND v(dout0_17) AT=210.05n

* CHECK dout0_18 Vdout0_18ck20 = 0 time = 210
.meas tran vdout0_18ck20 FIND v(dout0_18) AT=210.05n

* CHECK dout0_19 Vdout0_19ck20 = 0 time = 210
.meas tran vdout0_19ck20 FIND v(dout0_19) AT=210.05n

* CHECK dout0_20 Vdout0_20ck20 = 1.8 time = 210
.meas tran vdout0_20ck20 FIND v(dout0_20) AT=210.05n

* CHECK dout0_21 Vdout0_21ck20 = 0 time = 210
.meas tran vdout0_21ck20 FIND v(dout0_21) AT=210.05n

* CHECK dout0_22 Vdout0_22ck20 = 0 time = 210
.meas tran vdout0_22ck20 FIND v(dout0_22) AT=210.05n

* CHECK dout0_23 Vdout0_23ck20 = 1.8 time = 210
.meas tran vdout0_23ck20 FIND v(dout0_23) AT=210.05n

* CHECK dout0_24 Vdout0_24ck20 = 1.8 time = 210
.meas tran vdout0_24ck20 FIND v(dout0_24) AT=210.05n

* CHECK dout0_25 Vdout0_25ck20 = 1.8 time = 210
.meas tran vdout0_25ck20 FIND v(dout0_25) AT=210.05n

* CHECK dout0_26 Vdout0_26ck20 = 1.8 time = 210
.meas tran vdout0_26ck20 FIND v(dout0_26) AT=210.05n

* CHECK dout0_27 Vdout0_27ck20 = 0 time = 210
.meas tran vdout0_27ck20 FIND v(dout0_27) AT=210.05n

* CHECK dout0_28 Vdout0_28ck20 = 1.8 time = 210
.meas tran vdout0_28ck20 FIND v(dout0_28) AT=210.05n

* CHECK dout0_29 Vdout0_29ck20 = 0 time = 210
.meas tran vdout0_29ck20 FIND v(dout0_29) AT=210.05n

* CHECK dout0_30 Vdout0_30ck20 = 0 time = 210
.meas tran vdout0_30ck20 FIND v(dout0_30) AT=210.05n

* CHECK dout0_31 Vdout0_31ck20 = 0 time = 210
.meas tran vdout0_31ck20 FIND v(dout0_31) AT=210.05n

* CHECK dout0_32 Vdout0_32ck20 = 0 time = 210
.meas tran vdout0_32ck20 FIND v(dout0_32) AT=210.05n

* CHECK dout0_0 Vdout0_0ck21 = 0 time = 220
.meas tran vdout0_0ck21 FIND v(dout0_0) AT=220.05n

* CHECK dout0_1 Vdout0_1ck21 = 0 time = 220
.meas tran vdout0_1ck21 FIND v(dout0_1) AT=220.05n

* CHECK dout0_2 Vdout0_2ck21 = 0 time = 220
.meas tran vdout0_2ck21 FIND v(dout0_2) AT=220.05n

* CHECK dout0_3 Vdout0_3ck21 = 1.8 time = 220
.meas tran vdout0_3ck21 FIND v(dout0_3) AT=220.05n

* CHECK dout0_4 Vdout0_4ck21 = 1.8 time = 220
.meas tran vdout0_4ck21 FIND v(dout0_4) AT=220.05n

* CHECK dout0_5 Vdout0_5ck21 = 1.8 time = 220
.meas tran vdout0_5ck21 FIND v(dout0_5) AT=220.05n

* CHECK dout0_6 Vdout0_6ck21 = 0 time = 220
.meas tran vdout0_6ck21 FIND v(dout0_6) AT=220.05n

* CHECK dout0_7 Vdout0_7ck21 = 0 time = 220
.meas tran vdout0_7ck21 FIND v(dout0_7) AT=220.05n

* CHECK dout0_8 Vdout0_8ck21 = 1.8 time = 220
.meas tran vdout0_8ck21 FIND v(dout0_8) AT=220.05n

* CHECK dout0_9 Vdout0_9ck21 = 0 time = 220
.meas tran vdout0_9ck21 FIND v(dout0_9) AT=220.05n

* CHECK dout0_10 Vdout0_10ck21 = 1.8 time = 220
.meas tran vdout0_10ck21 FIND v(dout0_10) AT=220.05n

* CHECK dout0_11 Vdout0_11ck21 = 1.8 time = 220
.meas tran vdout0_11ck21 FIND v(dout0_11) AT=220.05n

* CHECK dout0_12 Vdout0_12ck21 = 0 time = 220
.meas tran vdout0_12ck21 FIND v(dout0_12) AT=220.05n

* CHECK dout0_13 Vdout0_13ck21 = 0 time = 220
.meas tran vdout0_13ck21 FIND v(dout0_13) AT=220.05n

* CHECK dout0_14 Vdout0_14ck21 = 1.8 time = 220
.meas tran vdout0_14ck21 FIND v(dout0_14) AT=220.05n

* CHECK dout0_15 Vdout0_15ck21 = 1.8 time = 220
.meas tran vdout0_15ck21 FIND v(dout0_15) AT=220.05n

* CHECK dout0_16 Vdout0_16ck21 = 1.8 time = 220
.meas tran vdout0_16ck21 FIND v(dout0_16) AT=220.05n

* CHECK dout0_17 Vdout0_17ck21 = 0 time = 220
.meas tran vdout0_17ck21 FIND v(dout0_17) AT=220.05n

* CHECK dout0_18 Vdout0_18ck21 = 0 time = 220
.meas tran vdout0_18ck21 FIND v(dout0_18) AT=220.05n

* CHECK dout0_19 Vdout0_19ck21 = 0 time = 220
.meas tran vdout0_19ck21 FIND v(dout0_19) AT=220.05n

* CHECK dout0_20 Vdout0_20ck21 = 1.8 time = 220
.meas tran vdout0_20ck21 FIND v(dout0_20) AT=220.05n

* CHECK dout0_21 Vdout0_21ck21 = 0 time = 220
.meas tran vdout0_21ck21 FIND v(dout0_21) AT=220.05n

* CHECK dout0_22 Vdout0_22ck21 = 0 time = 220
.meas tran vdout0_22ck21 FIND v(dout0_22) AT=220.05n

* CHECK dout0_23 Vdout0_23ck21 = 1.8 time = 220
.meas tran vdout0_23ck21 FIND v(dout0_23) AT=220.05n

* CHECK dout0_24 Vdout0_24ck21 = 1.8 time = 220
.meas tran vdout0_24ck21 FIND v(dout0_24) AT=220.05n

* CHECK dout0_25 Vdout0_25ck21 = 1.8 time = 220
.meas tran vdout0_25ck21 FIND v(dout0_25) AT=220.05n

* CHECK dout0_26 Vdout0_26ck21 = 1.8 time = 220
.meas tran vdout0_26ck21 FIND v(dout0_26) AT=220.05n

* CHECK dout0_27 Vdout0_27ck21 = 0 time = 220
.meas tran vdout0_27ck21 FIND v(dout0_27) AT=220.05n

* CHECK dout0_28 Vdout0_28ck21 = 1.8 time = 220
.meas tran vdout0_28ck21 FIND v(dout0_28) AT=220.05n

* CHECK dout0_29 Vdout0_29ck21 = 0 time = 220
.meas tran vdout0_29ck21 FIND v(dout0_29) AT=220.05n

* CHECK dout0_30 Vdout0_30ck21 = 0 time = 220
.meas tran vdout0_30ck21 FIND v(dout0_30) AT=220.05n

* CHECK dout0_31 Vdout0_31ck21 = 0 time = 220
.meas tran vdout0_31ck21 FIND v(dout0_31) AT=220.05n

* CHECK dout0_32 Vdout0_32ck21 = 0 time = 220
.meas tran vdout0_32ck21 FIND v(dout0_32) AT=220.05n

* CHECK dout0_0 Vdout0_0ck23 = 0 time = 240
.meas tran vdout0_0ck23 FIND v(dout0_0) AT=240.05n

* CHECK dout0_1 Vdout0_1ck23 = 0 time = 240
.meas tran vdout0_1ck23 FIND v(dout0_1) AT=240.05n

* CHECK dout0_2 Vdout0_2ck23 = 0 time = 240
.meas tran vdout0_2ck23 FIND v(dout0_2) AT=240.05n

* CHECK dout0_3 Vdout0_3ck23 = 1.8 time = 240
.meas tran vdout0_3ck23 FIND v(dout0_3) AT=240.05n

* CHECK dout0_4 Vdout0_4ck23 = 1.8 time = 240
.meas tran vdout0_4ck23 FIND v(dout0_4) AT=240.05n

* CHECK dout0_5 Vdout0_5ck23 = 1.8 time = 240
.meas tran vdout0_5ck23 FIND v(dout0_5) AT=240.05n

* CHECK dout0_6 Vdout0_6ck23 = 0 time = 240
.meas tran vdout0_6ck23 FIND v(dout0_6) AT=240.05n

* CHECK dout0_7 Vdout0_7ck23 = 0 time = 240
.meas tran vdout0_7ck23 FIND v(dout0_7) AT=240.05n

* CHECK dout0_8 Vdout0_8ck23 = 1.8 time = 240
.meas tran vdout0_8ck23 FIND v(dout0_8) AT=240.05n

* CHECK dout0_9 Vdout0_9ck23 = 0 time = 240
.meas tran vdout0_9ck23 FIND v(dout0_9) AT=240.05n

* CHECK dout0_10 Vdout0_10ck23 = 1.8 time = 240
.meas tran vdout0_10ck23 FIND v(dout0_10) AT=240.05n

* CHECK dout0_11 Vdout0_11ck23 = 1.8 time = 240
.meas tran vdout0_11ck23 FIND v(dout0_11) AT=240.05n

* CHECK dout0_12 Vdout0_12ck23 = 0 time = 240
.meas tran vdout0_12ck23 FIND v(dout0_12) AT=240.05n

* CHECK dout0_13 Vdout0_13ck23 = 0 time = 240
.meas tran vdout0_13ck23 FIND v(dout0_13) AT=240.05n

* CHECK dout0_14 Vdout0_14ck23 = 1.8 time = 240
.meas tran vdout0_14ck23 FIND v(dout0_14) AT=240.05n

* CHECK dout0_15 Vdout0_15ck23 = 1.8 time = 240
.meas tran vdout0_15ck23 FIND v(dout0_15) AT=240.05n

* CHECK dout0_16 Vdout0_16ck23 = 1.8 time = 240
.meas tran vdout0_16ck23 FIND v(dout0_16) AT=240.05n

* CHECK dout0_17 Vdout0_17ck23 = 0 time = 240
.meas tran vdout0_17ck23 FIND v(dout0_17) AT=240.05n

* CHECK dout0_18 Vdout0_18ck23 = 0 time = 240
.meas tran vdout0_18ck23 FIND v(dout0_18) AT=240.05n

* CHECK dout0_19 Vdout0_19ck23 = 0 time = 240
.meas tran vdout0_19ck23 FIND v(dout0_19) AT=240.05n

* CHECK dout0_20 Vdout0_20ck23 = 1.8 time = 240
.meas tran vdout0_20ck23 FIND v(dout0_20) AT=240.05n

* CHECK dout0_21 Vdout0_21ck23 = 0 time = 240
.meas tran vdout0_21ck23 FIND v(dout0_21) AT=240.05n

* CHECK dout0_22 Vdout0_22ck23 = 0 time = 240
.meas tran vdout0_22ck23 FIND v(dout0_22) AT=240.05n

* CHECK dout0_23 Vdout0_23ck23 = 1.8 time = 240
.meas tran vdout0_23ck23 FIND v(dout0_23) AT=240.05n

* CHECK dout0_24 Vdout0_24ck23 = 1.8 time = 240
.meas tran vdout0_24ck23 FIND v(dout0_24) AT=240.05n

* CHECK dout0_25 Vdout0_25ck23 = 1.8 time = 240
.meas tran vdout0_25ck23 FIND v(dout0_25) AT=240.05n

* CHECK dout0_26 Vdout0_26ck23 = 1.8 time = 240
.meas tran vdout0_26ck23 FIND v(dout0_26) AT=240.05n

* CHECK dout0_27 Vdout0_27ck23 = 0 time = 240
.meas tran vdout0_27ck23 FIND v(dout0_27) AT=240.05n

* CHECK dout0_28 Vdout0_28ck23 = 1.8 time = 240
.meas tran vdout0_28ck23 FIND v(dout0_28) AT=240.05n

* CHECK dout0_29 Vdout0_29ck23 = 0 time = 240
.meas tran vdout0_29ck23 FIND v(dout0_29) AT=240.05n

* CHECK dout0_30 Vdout0_30ck23 = 0 time = 240
.meas tran vdout0_30ck23 FIND v(dout0_30) AT=240.05n

* CHECK dout0_31 Vdout0_31ck23 = 0 time = 240
.meas tran vdout0_31ck23 FIND v(dout0_31) AT=240.05n

* CHECK dout0_32 Vdout0_32ck23 = 0 time = 240
.meas tran vdout0_32ck23 FIND v(dout0_32) AT=240.05n

* CHECK dout0_0 Vdout0_0ck26 = 1.8 time = 270
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=270.05n

* CHECK dout0_1 Vdout0_1ck26 = 1.8 time = 270
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=270.05n

* CHECK dout0_2 Vdout0_2ck26 = 1.8 time = 270
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=270.05n

* CHECK dout0_3 Vdout0_3ck26 = 1.8 time = 270
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=270.05n

* CHECK dout0_4 Vdout0_4ck26 = 0 time = 270
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=270.05n

* CHECK dout0_5 Vdout0_5ck26 = 1.8 time = 270
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=270.05n

* CHECK dout0_6 Vdout0_6ck26 = 1.8 time = 270
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=270.05n

* CHECK dout0_7 Vdout0_7ck26 = 1.8 time = 270
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=270.05n

* CHECK dout0_8 Vdout0_8ck26 = 1.8 time = 270
.meas tran vdout0_8ck26 FIND v(dout0_8) AT=270.05n

* CHECK dout0_9 Vdout0_9ck26 = 1.8 time = 270
.meas tran vdout0_9ck26 FIND v(dout0_9) AT=270.05n

* CHECK dout0_10 Vdout0_10ck26 = 1.8 time = 270
.meas tran vdout0_10ck26 FIND v(dout0_10) AT=270.05n

* CHECK dout0_11 Vdout0_11ck26 = 1.8 time = 270
.meas tran vdout0_11ck26 FIND v(dout0_11) AT=270.05n

* CHECK dout0_12 Vdout0_12ck26 = 0 time = 270
.meas tran vdout0_12ck26 FIND v(dout0_12) AT=270.05n

* CHECK dout0_13 Vdout0_13ck26 = 1.8 time = 270
.meas tran vdout0_13ck26 FIND v(dout0_13) AT=270.05n

* CHECK dout0_14 Vdout0_14ck26 = 0 time = 270
.meas tran vdout0_14ck26 FIND v(dout0_14) AT=270.05n

* CHECK dout0_15 Vdout0_15ck26 = 1.8 time = 270
.meas tran vdout0_15ck26 FIND v(dout0_15) AT=270.05n

* CHECK dout0_16 Vdout0_16ck26 = 1.8 time = 270
.meas tran vdout0_16ck26 FIND v(dout0_16) AT=270.05n

* CHECK dout0_17 Vdout0_17ck26 = 1.8 time = 270
.meas tran vdout0_17ck26 FIND v(dout0_17) AT=270.05n

* CHECK dout0_18 Vdout0_18ck26 = 1.8 time = 270
.meas tran vdout0_18ck26 FIND v(dout0_18) AT=270.05n

* CHECK dout0_19 Vdout0_19ck26 = 0 time = 270
.meas tran vdout0_19ck26 FIND v(dout0_19) AT=270.05n

* CHECK dout0_20 Vdout0_20ck26 = 1.8 time = 270
.meas tran vdout0_20ck26 FIND v(dout0_20) AT=270.05n

* CHECK dout0_21 Vdout0_21ck26 = 1.8 time = 270
.meas tran vdout0_21ck26 FIND v(dout0_21) AT=270.05n

* CHECK dout0_22 Vdout0_22ck26 = 0 time = 270
.meas tran vdout0_22ck26 FIND v(dout0_22) AT=270.05n

* CHECK dout0_23 Vdout0_23ck26 = 1.8 time = 270
.meas tran vdout0_23ck26 FIND v(dout0_23) AT=270.05n

* CHECK dout0_24 Vdout0_24ck26 = 0 time = 270
.meas tran vdout0_24ck26 FIND v(dout0_24) AT=270.05n

* CHECK dout0_25 Vdout0_25ck26 = 1.8 time = 270
.meas tran vdout0_25ck26 FIND v(dout0_25) AT=270.05n

* CHECK dout0_26 Vdout0_26ck26 = 0 time = 270
.meas tran vdout0_26ck26 FIND v(dout0_26) AT=270.05n

* CHECK dout0_27 Vdout0_27ck26 = 0 time = 270
.meas tran vdout0_27ck26 FIND v(dout0_27) AT=270.05n

* CHECK dout0_28 Vdout0_28ck26 = 0 time = 270
.meas tran vdout0_28ck26 FIND v(dout0_28) AT=270.05n

* CHECK dout0_29 Vdout0_29ck26 = 1.8 time = 270
.meas tran vdout0_29ck26 FIND v(dout0_29) AT=270.05n

* CHECK dout0_30 Vdout0_30ck26 = 0 time = 270
.meas tran vdout0_30ck26 FIND v(dout0_30) AT=270.05n

* CHECK dout0_31 Vdout0_31ck26 = 1.8 time = 270
.meas tran vdout0_31ck26 FIND v(dout0_31) AT=270.05n

* CHECK dout0_32 Vdout0_32ck26 = 0 time = 270
.meas tran vdout0_32ck26 FIND v(dout0_32) AT=270.05n

* CHECK dout0_0 Vdout0_0ck28 = 1.8 time = 290
.meas tran vdout0_0ck28 FIND v(dout0_0) AT=290.05n

* CHECK dout0_1 Vdout0_1ck28 = 1.8 time = 290
.meas tran vdout0_1ck28 FIND v(dout0_1) AT=290.05n

* CHECK dout0_2 Vdout0_2ck28 = 1.8 time = 290
.meas tran vdout0_2ck28 FIND v(dout0_2) AT=290.05n

* CHECK dout0_3 Vdout0_3ck28 = 1.8 time = 290
.meas tran vdout0_3ck28 FIND v(dout0_3) AT=290.05n

* CHECK dout0_4 Vdout0_4ck28 = 0 time = 290
.meas tran vdout0_4ck28 FIND v(dout0_4) AT=290.05n

* CHECK dout0_5 Vdout0_5ck28 = 1.8 time = 290
.meas tran vdout0_5ck28 FIND v(dout0_5) AT=290.05n

* CHECK dout0_6 Vdout0_6ck28 = 1.8 time = 290
.meas tran vdout0_6ck28 FIND v(dout0_6) AT=290.05n

* CHECK dout0_7 Vdout0_7ck28 = 1.8 time = 290
.meas tran vdout0_7ck28 FIND v(dout0_7) AT=290.05n

* CHECK dout0_8 Vdout0_8ck28 = 1.8 time = 290
.meas tran vdout0_8ck28 FIND v(dout0_8) AT=290.05n

* CHECK dout0_9 Vdout0_9ck28 = 1.8 time = 290
.meas tran vdout0_9ck28 FIND v(dout0_9) AT=290.05n

* CHECK dout0_10 Vdout0_10ck28 = 1.8 time = 290
.meas tran vdout0_10ck28 FIND v(dout0_10) AT=290.05n

* CHECK dout0_11 Vdout0_11ck28 = 1.8 time = 290
.meas tran vdout0_11ck28 FIND v(dout0_11) AT=290.05n

* CHECK dout0_12 Vdout0_12ck28 = 0 time = 290
.meas tran vdout0_12ck28 FIND v(dout0_12) AT=290.05n

* CHECK dout0_13 Vdout0_13ck28 = 1.8 time = 290
.meas tran vdout0_13ck28 FIND v(dout0_13) AT=290.05n

* CHECK dout0_14 Vdout0_14ck28 = 0 time = 290
.meas tran vdout0_14ck28 FIND v(dout0_14) AT=290.05n

* CHECK dout0_15 Vdout0_15ck28 = 1.8 time = 290
.meas tran vdout0_15ck28 FIND v(dout0_15) AT=290.05n

* CHECK dout0_16 Vdout0_16ck28 = 1.8 time = 290
.meas tran vdout0_16ck28 FIND v(dout0_16) AT=290.05n

* CHECK dout0_17 Vdout0_17ck28 = 1.8 time = 290
.meas tran vdout0_17ck28 FIND v(dout0_17) AT=290.05n

* CHECK dout0_18 Vdout0_18ck28 = 1.8 time = 290
.meas tran vdout0_18ck28 FIND v(dout0_18) AT=290.05n

* CHECK dout0_19 Vdout0_19ck28 = 0 time = 290
.meas tran vdout0_19ck28 FIND v(dout0_19) AT=290.05n

* CHECK dout0_20 Vdout0_20ck28 = 1.8 time = 290
.meas tran vdout0_20ck28 FIND v(dout0_20) AT=290.05n

* CHECK dout0_21 Vdout0_21ck28 = 1.8 time = 290
.meas tran vdout0_21ck28 FIND v(dout0_21) AT=290.05n

* CHECK dout0_22 Vdout0_22ck28 = 0 time = 290
.meas tran vdout0_22ck28 FIND v(dout0_22) AT=290.05n

* CHECK dout0_23 Vdout0_23ck28 = 1.8 time = 290
.meas tran vdout0_23ck28 FIND v(dout0_23) AT=290.05n

* CHECK dout0_24 Vdout0_24ck28 = 0 time = 290
.meas tran vdout0_24ck28 FIND v(dout0_24) AT=290.05n

* CHECK dout0_25 Vdout0_25ck28 = 1.8 time = 290
.meas tran vdout0_25ck28 FIND v(dout0_25) AT=290.05n

* CHECK dout0_26 Vdout0_26ck28 = 0 time = 290
.meas tran vdout0_26ck28 FIND v(dout0_26) AT=290.05n

* CHECK dout0_27 Vdout0_27ck28 = 0 time = 290
.meas tran vdout0_27ck28 FIND v(dout0_27) AT=290.05n

* CHECK dout0_28 Vdout0_28ck28 = 0 time = 290
.meas tran vdout0_28ck28 FIND v(dout0_28) AT=290.05n

* CHECK dout0_29 Vdout0_29ck28 = 1.8 time = 290
.meas tran vdout0_29ck28 FIND v(dout0_29) AT=290.05n

* CHECK dout0_30 Vdout0_30ck28 = 0 time = 290
.meas tran vdout0_30ck28 FIND v(dout0_30) AT=290.05n

* CHECK dout0_31 Vdout0_31ck28 = 1.8 time = 290
.meas tran vdout0_31ck28 FIND v(dout0_31) AT=290.05n

* CHECK dout0_32 Vdout0_32ck28 = 0 time = 290
.meas tran vdout0_32ck28 FIND v(dout0_32) AT=290.05n

* CHECK dout0_0 Vdout0_0ck32 = 0 time = 330
.meas tran vdout0_0ck32 FIND v(dout0_0) AT=330.05n

* CHECK dout0_1 Vdout0_1ck32 = 0 time = 330
.meas tran vdout0_1ck32 FIND v(dout0_1) AT=330.05n

* CHECK dout0_2 Vdout0_2ck32 = 0 time = 330
.meas tran vdout0_2ck32 FIND v(dout0_2) AT=330.05n

* CHECK dout0_3 Vdout0_3ck32 = 1.8 time = 330
.meas tran vdout0_3ck32 FIND v(dout0_3) AT=330.05n

* CHECK dout0_4 Vdout0_4ck32 = 1.8 time = 330
.meas tran vdout0_4ck32 FIND v(dout0_4) AT=330.05n

* CHECK dout0_5 Vdout0_5ck32 = 0 time = 330
.meas tran vdout0_5ck32 FIND v(dout0_5) AT=330.05n

* CHECK dout0_6 Vdout0_6ck32 = 1.8 time = 330
.meas tran vdout0_6ck32 FIND v(dout0_6) AT=330.05n

* CHECK dout0_7 Vdout0_7ck32 = 1.8 time = 330
.meas tran vdout0_7ck32 FIND v(dout0_7) AT=330.05n

* CHECK dout0_8 Vdout0_8ck32 = 1.8 time = 330
.meas tran vdout0_8ck32 FIND v(dout0_8) AT=330.05n

* CHECK dout0_9 Vdout0_9ck32 = 0 time = 330
.meas tran vdout0_9ck32 FIND v(dout0_9) AT=330.05n

* CHECK dout0_10 Vdout0_10ck32 = 0 time = 330
.meas tran vdout0_10ck32 FIND v(dout0_10) AT=330.05n

* CHECK dout0_11 Vdout0_11ck32 = 1.8 time = 330
.meas tran vdout0_11ck32 FIND v(dout0_11) AT=330.05n

* CHECK dout0_12 Vdout0_12ck32 = 1.8 time = 330
.meas tran vdout0_12ck32 FIND v(dout0_12) AT=330.05n

* CHECK dout0_13 Vdout0_13ck32 = 1.8 time = 330
.meas tran vdout0_13ck32 FIND v(dout0_13) AT=330.05n

* CHECK dout0_14 Vdout0_14ck32 = 0 time = 330
.meas tran vdout0_14ck32 FIND v(dout0_14) AT=330.05n

* CHECK dout0_15 Vdout0_15ck32 = 0 time = 330
.meas tran vdout0_15ck32 FIND v(dout0_15) AT=330.05n

* CHECK dout0_16 Vdout0_16ck32 = 1.8 time = 330
.meas tran vdout0_16ck32 FIND v(dout0_16) AT=330.05n

* CHECK dout0_17 Vdout0_17ck32 = 1.8 time = 330
.meas tran vdout0_17ck32 FIND v(dout0_17) AT=330.05n

* CHECK dout0_18 Vdout0_18ck32 = 1.8 time = 330
.meas tran vdout0_18ck32 FIND v(dout0_18) AT=330.05n

* CHECK dout0_19 Vdout0_19ck32 = 0 time = 330
.meas tran vdout0_19ck32 FIND v(dout0_19) AT=330.05n

* CHECK dout0_20 Vdout0_20ck32 = 1.8 time = 330
.meas tran vdout0_20ck32 FIND v(dout0_20) AT=330.05n

* CHECK dout0_21 Vdout0_21ck32 = 1.8 time = 330
.meas tran vdout0_21ck32 FIND v(dout0_21) AT=330.05n

* CHECK dout0_22 Vdout0_22ck32 = 1.8 time = 330
.meas tran vdout0_22ck32 FIND v(dout0_22) AT=330.05n

* CHECK dout0_23 Vdout0_23ck32 = 1.8 time = 330
.meas tran vdout0_23ck32 FIND v(dout0_23) AT=330.05n

* CHECK dout0_24 Vdout0_24ck32 = 1.8 time = 330
.meas tran vdout0_24ck32 FIND v(dout0_24) AT=330.05n

* CHECK dout0_25 Vdout0_25ck32 = 0 time = 330
.meas tran vdout0_25ck32 FIND v(dout0_25) AT=330.05n

* CHECK dout0_26 Vdout0_26ck32 = 0 time = 330
.meas tran vdout0_26ck32 FIND v(dout0_26) AT=330.05n

* CHECK dout0_27 Vdout0_27ck32 = 0 time = 330
.meas tran vdout0_27ck32 FIND v(dout0_27) AT=330.05n

* CHECK dout0_28 Vdout0_28ck32 = 0 time = 330
.meas tran vdout0_28ck32 FIND v(dout0_28) AT=330.05n

* CHECK dout0_29 Vdout0_29ck32 = 1.8 time = 330
.meas tran vdout0_29ck32 FIND v(dout0_29) AT=330.05n

* CHECK dout0_30 Vdout0_30ck32 = 1.8 time = 330
.meas tran vdout0_30ck32 FIND v(dout0_30) AT=330.05n

* CHECK dout0_31 Vdout0_31ck32 = 1.8 time = 330
.meas tran vdout0_31ck32 FIND v(dout0_31) AT=330.05n

* CHECK dout0_32 Vdout0_32ck32 = 0 time = 330
.meas tran vdout0_32ck32 FIND v(dout0_32) AT=330.05n

* CHECK dout0_0 Vdout0_0ck33 = 1.8 time = 340
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=340.05n

* CHECK dout0_1 Vdout0_1ck33 = 0 time = 340
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=340.05n

* CHECK dout0_2 Vdout0_2ck33 = 1.8 time = 340
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=340.05n

* CHECK dout0_3 Vdout0_3ck33 = 0 time = 340
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=340.05n

* CHECK dout0_4 Vdout0_4ck33 = 0 time = 340
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=340.05n

* CHECK dout0_5 Vdout0_5ck33 = 0 time = 340
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=340.05n

* CHECK dout0_6 Vdout0_6ck33 = 0 time = 340
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=340.05n

* CHECK dout0_7 Vdout0_7ck33 = 1.8 time = 340
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=340.05n

* CHECK dout0_8 Vdout0_8ck33 = 0 time = 340
.meas tran vdout0_8ck33 FIND v(dout0_8) AT=340.05n

* CHECK dout0_9 Vdout0_9ck33 = 1.8 time = 340
.meas tran vdout0_9ck33 FIND v(dout0_9) AT=340.05n

* CHECK dout0_10 Vdout0_10ck33 = 1.8 time = 340
.meas tran vdout0_10ck33 FIND v(dout0_10) AT=340.05n

* CHECK dout0_11 Vdout0_11ck33 = 0 time = 340
.meas tran vdout0_11ck33 FIND v(dout0_11) AT=340.05n

* CHECK dout0_12 Vdout0_12ck33 = 1.8 time = 340
.meas tran vdout0_12ck33 FIND v(dout0_12) AT=340.05n

* CHECK dout0_13 Vdout0_13ck33 = 0 time = 340
.meas tran vdout0_13ck33 FIND v(dout0_13) AT=340.05n

* CHECK dout0_14 Vdout0_14ck33 = 0 time = 340
.meas tran vdout0_14ck33 FIND v(dout0_14) AT=340.05n

* CHECK dout0_15 Vdout0_15ck33 = 0 time = 340
.meas tran vdout0_15ck33 FIND v(dout0_15) AT=340.05n

* CHECK dout0_16 Vdout0_16ck33 = 1.8 time = 340
.meas tran vdout0_16ck33 FIND v(dout0_16) AT=340.05n

* CHECK dout0_17 Vdout0_17ck33 = 1.8 time = 340
.meas tran vdout0_17ck33 FIND v(dout0_17) AT=340.05n

* CHECK dout0_18 Vdout0_18ck33 = 1.8 time = 340
.meas tran vdout0_18ck33 FIND v(dout0_18) AT=340.05n

* CHECK dout0_19 Vdout0_19ck33 = 0 time = 340
.meas tran vdout0_19ck33 FIND v(dout0_19) AT=340.05n

* CHECK dout0_20 Vdout0_20ck33 = 0 time = 340
.meas tran vdout0_20ck33 FIND v(dout0_20) AT=340.05n

* CHECK dout0_21 Vdout0_21ck33 = 1.8 time = 340
.meas tran vdout0_21ck33 FIND v(dout0_21) AT=340.05n

* CHECK dout0_22 Vdout0_22ck33 = 0 time = 340
.meas tran vdout0_22ck33 FIND v(dout0_22) AT=340.05n

* CHECK dout0_23 Vdout0_23ck33 = 0 time = 340
.meas tran vdout0_23ck33 FIND v(dout0_23) AT=340.05n

* CHECK dout0_24 Vdout0_24ck33 = 0 time = 340
.meas tran vdout0_24ck33 FIND v(dout0_24) AT=340.05n

* CHECK dout0_25 Vdout0_25ck33 = 1.8 time = 340
.meas tran vdout0_25ck33 FIND v(dout0_25) AT=340.05n

* CHECK dout0_26 Vdout0_26ck33 = 1.8 time = 340
.meas tran vdout0_26ck33 FIND v(dout0_26) AT=340.05n

* CHECK dout0_27 Vdout0_27ck33 = 1.8 time = 340
.meas tran vdout0_27ck33 FIND v(dout0_27) AT=340.05n

* CHECK dout0_28 Vdout0_28ck33 = 0 time = 340
.meas tran vdout0_28ck33 FIND v(dout0_28) AT=340.05n

* CHECK dout0_29 Vdout0_29ck33 = 1.8 time = 340
.meas tran vdout0_29ck33 FIND v(dout0_29) AT=340.05n

* CHECK dout0_30 Vdout0_30ck33 = 0 time = 340
.meas tran vdout0_30ck33 FIND v(dout0_30) AT=340.05n

* CHECK dout0_31 Vdout0_31ck33 = 1.8 time = 340
.meas tran vdout0_31ck33 FIND v(dout0_31) AT=340.05n

* CHECK dout0_32 Vdout0_32ck33 = 0 time = 340
.meas tran vdout0_32ck33 FIND v(dout0_32) AT=340.05n

* CHECK dout0_0 Vdout0_0ck34 = 0 time = 350
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=350.05n

* CHECK dout0_1 Vdout0_1ck34 = 0 time = 350
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=350.05n

* CHECK dout0_2 Vdout0_2ck34 = 0 time = 350
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=350.05n

* CHECK dout0_3 Vdout0_3ck34 = 1.8 time = 350
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=350.05n

* CHECK dout0_4 Vdout0_4ck34 = 1.8 time = 350
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=350.05n

* CHECK dout0_5 Vdout0_5ck34 = 0 time = 350
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=350.05n

* CHECK dout0_6 Vdout0_6ck34 = 1.8 time = 350
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=350.05n

* CHECK dout0_7 Vdout0_7ck34 = 1.8 time = 350
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=350.05n

* CHECK dout0_8 Vdout0_8ck34 = 1.8 time = 350
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=350.05n

* CHECK dout0_9 Vdout0_9ck34 = 0 time = 350
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=350.05n

* CHECK dout0_10 Vdout0_10ck34 = 0 time = 350
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=350.05n

* CHECK dout0_11 Vdout0_11ck34 = 1.8 time = 350
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=350.05n

* CHECK dout0_12 Vdout0_12ck34 = 1.8 time = 350
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=350.05n

* CHECK dout0_13 Vdout0_13ck34 = 1.8 time = 350
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=350.05n

* CHECK dout0_14 Vdout0_14ck34 = 0 time = 350
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=350.05n

* CHECK dout0_15 Vdout0_15ck34 = 0 time = 350
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=350.05n

* CHECK dout0_16 Vdout0_16ck34 = 1.8 time = 350
.meas tran vdout0_16ck34 FIND v(dout0_16) AT=350.05n

* CHECK dout0_17 Vdout0_17ck34 = 1.8 time = 350
.meas tran vdout0_17ck34 FIND v(dout0_17) AT=350.05n

* CHECK dout0_18 Vdout0_18ck34 = 1.8 time = 350
.meas tran vdout0_18ck34 FIND v(dout0_18) AT=350.05n

* CHECK dout0_19 Vdout0_19ck34 = 0 time = 350
.meas tran vdout0_19ck34 FIND v(dout0_19) AT=350.05n

* CHECK dout0_20 Vdout0_20ck34 = 1.8 time = 350
.meas tran vdout0_20ck34 FIND v(dout0_20) AT=350.05n

* CHECK dout0_21 Vdout0_21ck34 = 1.8 time = 350
.meas tran vdout0_21ck34 FIND v(dout0_21) AT=350.05n

* CHECK dout0_22 Vdout0_22ck34 = 1.8 time = 350
.meas tran vdout0_22ck34 FIND v(dout0_22) AT=350.05n

* CHECK dout0_23 Vdout0_23ck34 = 1.8 time = 350
.meas tran vdout0_23ck34 FIND v(dout0_23) AT=350.05n

* CHECK dout0_24 Vdout0_24ck34 = 1.8 time = 350
.meas tran vdout0_24ck34 FIND v(dout0_24) AT=350.05n

* CHECK dout0_25 Vdout0_25ck34 = 0 time = 350
.meas tran vdout0_25ck34 FIND v(dout0_25) AT=350.05n

* CHECK dout0_26 Vdout0_26ck34 = 0 time = 350
.meas tran vdout0_26ck34 FIND v(dout0_26) AT=350.05n

* CHECK dout0_27 Vdout0_27ck34 = 0 time = 350
.meas tran vdout0_27ck34 FIND v(dout0_27) AT=350.05n

* CHECK dout0_28 Vdout0_28ck34 = 0 time = 350
.meas tran vdout0_28ck34 FIND v(dout0_28) AT=350.05n

* CHECK dout0_29 Vdout0_29ck34 = 1.8 time = 350
.meas tran vdout0_29ck34 FIND v(dout0_29) AT=350.05n

* CHECK dout0_30 Vdout0_30ck34 = 1.8 time = 350
.meas tran vdout0_30ck34 FIND v(dout0_30) AT=350.05n

* CHECK dout0_31 Vdout0_31ck34 = 1.8 time = 350
.meas tran vdout0_31ck34 FIND v(dout0_31) AT=350.05n

* CHECK dout0_32 Vdout0_32ck34 = 0 time = 350
.meas tran vdout0_32ck34 FIND v(dout0_32) AT=350.05n

* CHECK dout0_0 Vdout0_0ck35 = 1.8 time = 360
.meas tran vdout0_0ck35 FIND v(dout0_0) AT=360.05n

* CHECK dout0_1 Vdout0_1ck35 = 0 time = 360
.meas tran vdout0_1ck35 FIND v(dout0_1) AT=360.05n

* CHECK dout0_2 Vdout0_2ck35 = 1.8 time = 360
.meas tran vdout0_2ck35 FIND v(dout0_2) AT=360.05n

* CHECK dout0_3 Vdout0_3ck35 = 0 time = 360
.meas tran vdout0_3ck35 FIND v(dout0_3) AT=360.05n

* CHECK dout0_4 Vdout0_4ck35 = 0 time = 360
.meas tran vdout0_4ck35 FIND v(dout0_4) AT=360.05n

* CHECK dout0_5 Vdout0_5ck35 = 0 time = 360
.meas tran vdout0_5ck35 FIND v(dout0_5) AT=360.05n

* CHECK dout0_6 Vdout0_6ck35 = 0 time = 360
.meas tran vdout0_6ck35 FIND v(dout0_6) AT=360.05n

* CHECK dout0_7 Vdout0_7ck35 = 1.8 time = 360
.meas tran vdout0_7ck35 FIND v(dout0_7) AT=360.05n

* CHECK dout0_8 Vdout0_8ck35 = 0 time = 360
.meas tran vdout0_8ck35 FIND v(dout0_8) AT=360.05n

* CHECK dout0_9 Vdout0_9ck35 = 1.8 time = 360
.meas tran vdout0_9ck35 FIND v(dout0_9) AT=360.05n

* CHECK dout0_10 Vdout0_10ck35 = 1.8 time = 360
.meas tran vdout0_10ck35 FIND v(dout0_10) AT=360.05n

* CHECK dout0_11 Vdout0_11ck35 = 0 time = 360
.meas tran vdout0_11ck35 FIND v(dout0_11) AT=360.05n

* CHECK dout0_12 Vdout0_12ck35 = 1.8 time = 360
.meas tran vdout0_12ck35 FIND v(dout0_12) AT=360.05n

* CHECK dout0_13 Vdout0_13ck35 = 0 time = 360
.meas tran vdout0_13ck35 FIND v(dout0_13) AT=360.05n

* CHECK dout0_14 Vdout0_14ck35 = 0 time = 360
.meas tran vdout0_14ck35 FIND v(dout0_14) AT=360.05n

* CHECK dout0_15 Vdout0_15ck35 = 0 time = 360
.meas tran vdout0_15ck35 FIND v(dout0_15) AT=360.05n

* CHECK dout0_16 Vdout0_16ck35 = 1.8 time = 360
.meas tran vdout0_16ck35 FIND v(dout0_16) AT=360.05n

* CHECK dout0_17 Vdout0_17ck35 = 1.8 time = 360
.meas tran vdout0_17ck35 FIND v(dout0_17) AT=360.05n

* CHECK dout0_18 Vdout0_18ck35 = 1.8 time = 360
.meas tran vdout0_18ck35 FIND v(dout0_18) AT=360.05n

* CHECK dout0_19 Vdout0_19ck35 = 0 time = 360
.meas tran vdout0_19ck35 FIND v(dout0_19) AT=360.05n

* CHECK dout0_20 Vdout0_20ck35 = 0 time = 360
.meas tran vdout0_20ck35 FIND v(dout0_20) AT=360.05n

* CHECK dout0_21 Vdout0_21ck35 = 1.8 time = 360
.meas tran vdout0_21ck35 FIND v(dout0_21) AT=360.05n

* CHECK dout0_22 Vdout0_22ck35 = 0 time = 360
.meas tran vdout0_22ck35 FIND v(dout0_22) AT=360.05n

* CHECK dout0_23 Vdout0_23ck35 = 0 time = 360
.meas tran vdout0_23ck35 FIND v(dout0_23) AT=360.05n

* CHECK dout0_24 Vdout0_24ck35 = 0 time = 360
.meas tran vdout0_24ck35 FIND v(dout0_24) AT=360.05n

* CHECK dout0_25 Vdout0_25ck35 = 1.8 time = 360
.meas tran vdout0_25ck35 FIND v(dout0_25) AT=360.05n

* CHECK dout0_26 Vdout0_26ck35 = 1.8 time = 360
.meas tran vdout0_26ck35 FIND v(dout0_26) AT=360.05n

* CHECK dout0_27 Vdout0_27ck35 = 1.8 time = 360
.meas tran vdout0_27ck35 FIND v(dout0_27) AT=360.05n

* CHECK dout0_28 Vdout0_28ck35 = 0 time = 360
.meas tran vdout0_28ck35 FIND v(dout0_28) AT=360.05n

* CHECK dout0_29 Vdout0_29ck35 = 1.8 time = 360
.meas tran vdout0_29ck35 FIND v(dout0_29) AT=360.05n

* CHECK dout0_30 Vdout0_30ck35 = 0 time = 360
.meas tran vdout0_30ck35 FIND v(dout0_30) AT=360.05n

* CHECK dout0_31 Vdout0_31ck35 = 1.8 time = 360
.meas tran vdout0_31ck35 FIND v(dout0_31) AT=360.05n

* CHECK dout0_32 Vdout0_32ck35 = 0 time = 360
.meas tran vdout0_32ck35 FIND v(dout0_32) AT=360.05n

* CHECK dout0_0 Vdout0_0ck38 = 0 time = 390
.meas tran vdout0_0ck38 FIND v(dout0_0) AT=390.05n

* CHECK dout0_1 Vdout0_1ck38 = 0 time = 390
.meas tran vdout0_1ck38 FIND v(dout0_1) AT=390.05n

* CHECK dout0_2 Vdout0_2ck38 = 0 time = 390
.meas tran vdout0_2ck38 FIND v(dout0_2) AT=390.05n

* CHECK dout0_3 Vdout0_3ck38 = 1.8 time = 390
.meas tran vdout0_3ck38 FIND v(dout0_3) AT=390.05n

* CHECK dout0_4 Vdout0_4ck38 = 1.8 time = 390
.meas tran vdout0_4ck38 FIND v(dout0_4) AT=390.05n

* CHECK dout0_5 Vdout0_5ck38 = 0 time = 390
.meas tran vdout0_5ck38 FIND v(dout0_5) AT=390.05n

* CHECK dout0_6 Vdout0_6ck38 = 1.8 time = 390
.meas tran vdout0_6ck38 FIND v(dout0_6) AT=390.05n

* CHECK dout0_7 Vdout0_7ck38 = 1.8 time = 390
.meas tran vdout0_7ck38 FIND v(dout0_7) AT=390.05n

* CHECK dout0_8 Vdout0_8ck38 = 1.8 time = 390
.meas tran vdout0_8ck38 FIND v(dout0_8) AT=390.05n

* CHECK dout0_9 Vdout0_9ck38 = 0 time = 390
.meas tran vdout0_9ck38 FIND v(dout0_9) AT=390.05n

* CHECK dout0_10 Vdout0_10ck38 = 0 time = 390
.meas tran vdout0_10ck38 FIND v(dout0_10) AT=390.05n

* CHECK dout0_11 Vdout0_11ck38 = 1.8 time = 390
.meas tran vdout0_11ck38 FIND v(dout0_11) AT=390.05n

* CHECK dout0_12 Vdout0_12ck38 = 1.8 time = 390
.meas tran vdout0_12ck38 FIND v(dout0_12) AT=390.05n

* CHECK dout0_13 Vdout0_13ck38 = 1.8 time = 390
.meas tran vdout0_13ck38 FIND v(dout0_13) AT=390.05n

* CHECK dout0_14 Vdout0_14ck38 = 0 time = 390
.meas tran vdout0_14ck38 FIND v(dout0_14) AT=390.05n

* CHECK dout0_15 Vdout0_15ck38 = 0 time = 390
.meas tran vdout0_15ck38 FIND v(dout0_15) AT=390.05n

* CHECK dout0_16 Vdout0_16ck38 = 1.8 time = 390
.meas tran vdout0_16ck38 FIND v(dout0_16) AT=390.05n

* CHECK dout0_17 Vdout0_17ck38 = 1.8 time = 390
.meas tran vdout0_17ck38 FIND v(dout0_17) AT=390.05n

* CHECK dout0_18 Vdout0_18ck38 = 1.8 time = 390
.meas tran vdout0_18ck38 FIND v(dout0_18) AT=390.05n

* CHECK dout0_19 Vdout0_19ck38 = 0 time = 390
.meas tran vdout0_19ck38 FIND v(dout0_19) AT=390.05n

* CHECK dout0_20 Vdout0_20ck38 = 1.8 time = 390
.meas tran vdout0_20ck38 FIND v(dout0_20) AT=390.05n

* CHECK dout0_21 Vdout0_21ck38 = 1.8 time = 390
.meas tran vdout0_21ck38 FIND v(dout0_21) AT=390.05n

* CHECK dout0_22 Vdout0_22ck38 = 1.8 time = 390
.meas tran vdout0_22ck38 FIND v(dout0_22) AT=390.05n

* CHECK dout0_23 Vdout0_23ck38 = 1.8 time = 390
.meas tran vdout0_23ck38 FIND v(dout0_23) AT=390.05n

* CHECK dout0_24 Vdout0_24ck38 = 1.8 time = 390
.meas tran vdout0_24ck38 FIND v(dout0_24) AT=390.05n

* CHECK dout0_25 Vdout0_25ck38 = 0 time = 390
.meas tran vdout0_25ck38 FIND v(dout0_25) AT=390.05n

* CHECK dout0_26 Vdout0_26ck38 = 0 time = 390
.meas tran vdout0_26ck38 FIND v(dout0_26) AT=390.05n

* CHECK dout0_27 Vdout0_27ck38 = 0 time = 390
.meas tran vdout0_27ck38 FIND v(dout0_27) AT=390.05n

* CHECK dout0_28 Vdout0_28ck38 = 0 time = 390
.meas tran vdout0_28ck38 FIND v(dout0_28) AT=390.05n

* CHECK dout0_29 Vdout0_29ck38 = 1.8 time = 390
.meas tran vdout0_29ck38 FIND v(dout0_29) AT=390.05n

* CHECK dout0_30 Vdout0_30ck38 = 1.8 time = 390
.meas tran vdout0_30ck38 FIND v(dout0_30) AT=390.05n

* CHECK dout0_31 Vdout0_31ck38 = 1.8 time = 390
.meas tran vdout0_31ck38 FIND v(dout0_31) AT=390.05n

* CHECK dout0_32 Vdout0_32ck38 = 0 time = 390
.meas tran vdout0_32ck38 FIND v(dout0_32) AT=390.05n

* CHECK dout0_0 Vdout0_0ck39 = 1.8 time = 400
.meas tran vdout0_0ck39 FIND v(dout0_0) AT=400.05n

* CHECK dout0_1 Vdout0_1ck39 = 0 time = 400
.meas tran vdout0_1ck39 FIND v(dout0_1) AT=400.05n

* CHECK dout0_2 Vdout0_2ck39 = 1.8 time = 400
.meas tran vdout0_2ck39 FIND v(dout0_2) AT=400.05n

* CHECK dout0_3 Vdout0_3ck39 = 0 time = 400
.meas tran vdout0_3ck39 FIND v(dout0_3) AT=400.05n

* CHECK dout0_4 Vdout0_4ck39 = 0 time = 400
.meas tran vdout0_4ck39 FIND v(dout0_4) AT=400.05n

* CHECK dout0_5 Vdout0_5ck39 = 0 time = 400
.meas tran vdout0_5ck39 FIND v(dout0_5) AT=400.05n

* CHECK dout0_6 Vdout0_6ck39 = 0 time = 400
.meas tran vdout0_6ck39 FIND v(dout0_6) AT=400.05n

* CHECK dout0_7 Vdout0_7ck39 = 1.8 time = 400
.meas tran vdout0_7ck39 FIND v(dout0_7) AT=400.05n

* CHECK dout0_8 Vdout0_8ck39 = 0 time = 400
.meas tran vdout0_8ck39 FIND v(dout0_8) AT=400.05n

* CHECK dout0_9 Vdout0_9ck39 = 1.8 time = 400
.meas tran vdout0_9ck39 FIND v(dout0_9) AT=400.05n

* CHECK dout0_10 Vdout0_10ck39 = 1.8 time = 400
.meas tran vdout0_10ck39 FIND v(dout0_10) AT=400.05n

* CHECK dout0_11 Vdout0_11ck39 = 0 time = 400
.meas tran vdout0_11ck39 FIND v(dout0_11) AT=400.05n

* CHECK dout0_12 Vdout0_12ck39 = 1.8 time = 400
.meas tran vdout0_12ck39 FIND v(dout0_12) AT=400.05n

* CHECK dout0_13 Vdout0_13ck39 = 0 time = 400
.meas tran vdout0_13ck39 FIND v(dout0_13) AT=400.05n

* CHECK dout0_14 Vdout0_14ck39 = 0 time = 400
.meas tran vdout0_14ck39 FIND v(dout0_14) AT=400.05n

* CHECK dout0_15 Vdout0_15ck39 = 0 time = 400
.meas tran vdout0_15ck39 FIND v(dout0_15) AT=400.05n

* CHECK dout0_16 Vdout0_16ck39 = 1.8 time = 400
.meas tran vdout0_16ck39 FIND v(dout0_16) AT=400.05n

* CHECK dout0_17 Vdout0_17ck39 = 1.8 time = 400
.meas tran vdout0_17ck39 FIND v(dout0_17) AT=400.05n

* CHECK dout0_18 Vdout0_18ck39 = 1.8 time = 400
.meas tran vdout0_18ck39 FIND v(dout0_18) AT=400.05n

* CHECK dout0_19 Vdout0_19ck39 = 0 time = 400
.meas tran vdout0_19ck39 FIND v(dout0_19) AT=400.05n

* CHECK dout0_20 Vdout0_20ck39 = 0 time = 400
.meas tran vdout0_20ck39 FIND v(dout0_20) AT=400.05n

* CHECK dout0_21 Vdout0_21ck39 = 1.8 time = 400
.meas tran vdout0_21ck39 FIND v(dout0_21) AT=400.05n

* CHECK dout0_22 Vdout0_22ck39 = 0 time = 400
.meas tran vdout0_22ck39 FIND v(dout0_22) AT=400.05n

* CHECK dout0_23 Vdout0_23ck39 = 0 time = 400
.meas tran vdout0_23ck39 FIND v(dout0_23) AT=400.05n

* CHECK dout0_24 Vdout0_24ck39 = 0 time = 400
.meas tran vdout0_24ck39 FIND v(dout0_24) AT=400.05n

* CHECK dout0_25 Vdout0_25ck39 = 1.8 time = 400
.meas tran vdout0_25ck39 FIND v(dout0_25) AT=400.05n

* CHECK dout0_26 Vdout0_26ck39 = 1.8 time = 400
.meas tran vdout0_26ck39 FIND v(dout0_26) AT=400.05n

* CHECK dout0_27 Vdout0_27ck39 = 1.8 time = 400
.meas tran vdout0_27ck39 FIND v(dout0_27) AT=400.05n

* CHECK dout0_28 Vdout0_28ck39 = 0 time = 400
.meas tran vdout0_28ck39 FIND v(dout0_28) AT=400.05n

* CHECK dout0_29 Vdout0_29ck39 = 1.8 time = 400
.meas tran vdout0_29ck39 FIND v(dout0_29) AT=400.05n

* CHECK dout0_30 Vdout0_30ck39 = 0 time = 400
.meas tran vdout0_30ck39 FIND v(dout0_30) AT=400.05n

* CHECK dout0_31 Vdout0_31ck39 = 1.8 time = 400
.meas tran vdout0_31ck39 FIND v(dout0_31) AT=400.05n

* CHECK dout0_32 Vdout0_32ck39 = 0 time = 400
.meas tran vdout0_32ck39 FIND v(dout0_32) AT=400.05n

* CHECK dout0_0 Vdout0_0ck42 = 1.8 time = 430
.meas tran vdout0_0ck42 FIND v(dout0_0) AT=430.05n

* CHECK dout0_1 Vdout0_1ck42 = 0 time = 430
.meas tran vdout0_1ck42 FIND v(dout0_1) AT=430.05n

* CHECK dout0_2 Vdout0_2ck42 = 1.8 time = 430
.meas tran vdout0_2ck42 FIND v(dout0_2) AT=430.05n

* CHECK dout0_3 Vdout0_3ck42 = 1.8 time = 430
.meas tran vdout0_3ck42 FIND v(dout0_3) AT=430.05n

* CHECK dout0_4 Vdout0_4ck42 = 0 time = 430
.meas tran vdout0_4ck42 FIND v(dout0_4) AT=430.05n

* CHECK dout0_5 Vdout0_5ck42 = 1.8 time = 430
.meas tran vdout0_5ck42 FIND v(dout0_5) AT=430.05n

* CHECK dout0_6 Vdout0_6ck42 = 1.8 time = 430
.meas tran vdout0_6ck42 FIND v(dout0_6) AT=430.05n

* CHECK dout0_7 Vdout0_7ck42 = 0 time = 430
.meas tran vdout0_7ck42 FIND v(dout0_7) AT=430.05n

* CHECK dout0_8 Vdout0_8ck42 = 0 time = 430
.meas tran vdout0_8ck42 FIND v(dout0_8) AT=430.05n

* CHECK dout0_9 Vdout0_9ck42 = 0 time = 430
.meas tran vdout0_9ck42 FIND v(dout0_9) AT=430.05n

* CHECK dout0_10 Vdout0_10ck42 = 0 time = 430
.meas tran vdout0_10ck42 FIND v(dout0_10) AT=430.05n

* CHECK dout0_11 Vdout0_11ck42 = 0 time = 430
.meas tran vdout0_11ck42 FIND v(dout0_11) AT=430.05n

* CHECK dout0_12 Vdout0_12ck42 = 0 time = 430
.meas tran vdout0_12ck42 FIND v(dout0_12) AT=430.05n

* CHECK dout0_13 Vdout0_13ck42 = 0 time = 430
.meas tran vdout0_13ck42 FIND v(dout0_13) AT=430.05n

* CHECK dout0_14 Vdout0_14ck42 = 0 time = 430
.meas tran vdout0_14ck42 FIND v(dout0_14) AT=430.05n

* CHECK dout0_15 Vdout0_15ck42 = 1.8 time = 430
.meas tran vdout0_15ck42 FIND v(dout0_15) AT=430.05n

* CHECK dout0_16 Vdout0_16ck42 = 1.8 time = 430
.meas tran vdout0_16ck42 FIND v(dout0_16) AT=430.05n

* CHECK dout0_17 Vdout0_17ck42 = 1.8 time = 430
.meas tran vdout0_17ck42 FIND v(dout0_17) AT=430.05n

* CHECK dout0_18 Vdout0_18ck42 = 1.8 time = 430
.meas tran vdout0_18ck42 FIND v(dout0_18) AT=430.05n

* CHECK dout0_19 Vdout0_19ck42 = 0 time = 430
.meas tran vdout0_19ck42 FIND v(dout0_19) AT=430.05n

* CHECK dout0_20 Vdout0_20ck42 = 1.8 time = 430
.meas tran vdout0_20ck42 FIND v(dout0_20) AT=430.05n

* CHECK dout0_21 Vdout0_21ck42 = 0 time = 430
.meas tran vdout0_21ck42 FIND v(dout0_21) AT=430.05n

* CHECK dout0_22 Vdout0_22ck42 = 1.8 time = 430
.meas tran vdout0_22ck42 FIND v(dout0_22) AT=430.05n

* CHECK dout0_23 Vdout0_23ck42 = 1.8 time = 430
.meas tran vdout0_23ck42 FIND v(dout0_23) AT=430.05n

* CHECK dout0_24 Vdout0_24ck42 = 0 time = 430
.meas tran vdout0_24ck42 FIND v(dout0_24) AT=430.05n

* CHECK dout0_25 Vdout0_25ck42 = 0 time = 430
.meas tran vdout0_25ck42 FIND v(dout0_25) AT=430.05n

* CHECK dout0_26 Vdout0_26ck42 = 1.8 time = 430
.meas tran vdout0_26ck42 FIND v(dout0_26) AT=430.05n

* CHECK dout0_27 Vdout0_27ck42 = 0 time = 430
.meas tran vdout0_27ck42 FIND v(dout0_27) AT=430.05n

* CHECK dout0_28 Vdout0_28ck42 = 1.8 time = 430
.meas tran vdout0_28ck42 FIND v(dout0_28) AT=430.05n

* CHECK dout0_29 Vdout0_29ck42 = 1.8 time = 430
.meas tran vdout0_29ck42 FIND v(dout0_29) AT=430.05n

* CHECK dout0_30 Vdout0_30ck42 = 0 time = 430
.meas tran vdout0_30ck42 FIND v(dout0_30) AT=430.05n

* CHECK dout0_31 Vdout0_31ck42 = 0 time = 430
.meas tran vdout0_31ck42 FIND v(dout0_31) AT=430.05n

* CHECK dout0_32 Vdout0_32ck42 = 0 time = 430
.meas tran vdout0_32ck42 FIND v(dout0_32) AT=430.05n

* CHECK dout0_0 Vdout0_0ck43 = 1.8 time = 440
.meas tran vdout0_0ck43 FIND v(dout0_0) AT=440.05n

* CHECK dout0_1 Vdout0_1ck43 = 0 time = 440
.meas tran vdout0_1ck43 FIND v(dout0_1) AT=440.05n

* CHECK dout0_2 Vdout0_2ck43 = 1.8 time = 440
.meas tran vdout0_2ck43 FIND v(dout0_2) AT=440.05n

* CHECK dout0_3 Vdout0_3ck43 = 1.8 time = 440
.meas tran vdout0_3ck43 FIND v(dout0_3) AT=440.05n

* CHECK dout0_4 Vdout0_4ck43 = 0 time = 440
.meas tran vdout0_4ck43 FIND v(dout0_4) AT=440.05n

* CHECK dout0_5 Vdout0_5ck43 = 1.8 time = 440
.meas tran vdout0_5ck43 FIND v(dout0_5) AT=440.05n

* CHECK dout0_6 Vdout0_6ck43 = 1.8 time = 440
.meas tran vdout0_6ck43 FIND v(dout0_6) AT=440.05n

* CHECK dout0_7 Vdout0_7ck43 = 0 time = 440
.meas tran vdout0_7ck43 FIND v(dout0_7) AT=440.05n

* CHECK dout0_8 Vdout0_8ck43 = 0 time = 440
.meas tran vdout0_8ck43 FIND v(dout0_8) AT=440.05n

* CHECK dout0_9 Vdout0_9ck43 = 0 time = 440
.meas tran vdout0_9ck43 FIND v(dout0_9) AT=440.05n

* CHECK dout0_10 Vdout0_10ck43 = 0 time = 440
.meas tran vdout0_10ck43 FIND v(dout0_10) AT=440.05n

* CHECK dout0_11 Vdout0_11ck43 = 0 time = 440
.meas tran vdout0_11ck43 FIND v(dout0_11) AT=440.05n

* CHECK dout0_12 Vdout0_12ck43 = 0 time = 440
.meas tran vdout0_12ck43 FIND v(dout0_12) AT=440.05n

* CHECK dout0_13 Vdout0_13ck43 = 0 time = 440
.meas tran vdout0_13ck43 FIND v(dout0_13) AT=440.05n

* CHECK dout0_14 Vdout0_14ck43 = 0 time = 440
.meas tran vdout0_14ck43 FIND v(dout0_14) AT=440.05n

* CHECK dout0_15 Vdout0_15ck43 = 1.8 time = 440
.meas tran vdout0_15ck43 FIND v(dout0_15) AT=440.05n

* CHECK dout0_16 Vdout0_16ck43 = 1.8 time = 440
.meas tran vdout0_16ck43 FIND v(dout0_16) AT=440.05n

* CHECK dout0_17 Vdout0_17ck43 = 1.8 time = 440
.meas tran vdout0_17ck43 FIND v(dout0_17) AT=440.05n

* CHECK dout0_18 Vdout0_18ck43 = 1.8 time = 440
.meas tran vdout0_18ck43 FIND v(dout0_18) AT=440.05n

* CHECK dout0_19 Vdout0_19ck43 = 0 time = 440
.meas tran vdout0_19ck43 FIND v(dout0_19) AT=440.05n

* CHECK dout0_20 Vdout0_20ck43 = 1.8 time = 440
.meas tran vdout0_20ck43 FIND v(dout0_20) AT=440.05n

* CHECK dout0_21 Vdout0_21ck43 = 0 time = 440
.meas tran vdout0_21ck43 FIND v(dout0_21) AT=440.05n

* CHECK dout0_22 Vdout0_22ck43 = 1.8 time = 440
.meas tran vdout0_22ck43 FIND v(dout0_22) AT=440.05n

* CHECK dout0_23 Vdout0_23ck43 = 1.8 time = 440
.meas tran vdout0_23ck43 FIND v(dout0_23) AT=440.05n

* CHECK dout0_24 Vdout0_24ck43 = 0 time = 440
.meas tran vdout0_24ck43 FIND v(dout0_24) AT=440.05n

* CHECK dout0_25 Vdout0_25ck43 = 0 time = 440
.meas tran vdout0_25ck43 FIND v(dout0_25) AT=440.05n

* CHECK dout0_26 Vdout0_26ck43 = 1.8 time = 440
.meas tran vdout0_26ck43 FIND v(dout0_26) AT=440.05n

* CHECK dout0_27 Vdout0_27ck43 = 0 time = 440
.meas tran vdout0_27ck43 FIND v(dout0_27) AT=440.05n

* CHECK dout0_28 Vdout0_28ck43 = 1.8 time = 440
.meas tran vdout0_28ck43 FIND v(dout0_28) AT=440.05n

* CHECK dout0_29 Vdout0_29ck43 = 1.8 time = 440
.meas tran vdout0_29ck43 FIND v(dout0_29) AT=440.05n

* CHECK dout0_30 Vdout0_30ck43 = 0 time = 440
.meas tran vdout0_30ck43 FIND v(dout0_30) AT=440.05n

* CHECK dout0_31 Vdout0_31ck43 = 0 time = 440
.meas tran vdout0_31ck43 FIND v(dout0_31) AT=440.05n

* CHECK dout0_32 Vdout0_32ck43 = 0 time = 440
.meas tran vdout0_32ck43 FIND v(dout0_32) AT=440.05n

* CHECK dout0_0 Vdout0_0ck44 = 1.8 time = 450
.meas tran vdout0_0ck44 FIND v(dout0_0) AT=450.05n

* CHECK dout0_1 Vdout0_1ck44 = 0 time = 450
.meas tran vdout0_1ck44 FIND v(dout0_1) AT=450.05n

* CHECK dout0_2 Vdout0_2ck44 = 1.8 time = 450
.meas tran vdout0_2ck44 FIND v(dout0_2) AT=450.05n

* CHECK dout0_3 Vdout0_3ck44 = 0 time = 450
.meas tran vdout0_3ck44 FIND v(dout0_3) AT=450.05n

* CHECK dout0_4 Vdout0_4ck44 = 0 time = 450
.meas tran vdout0_4ck44 FIND v(dout0_4) AT=450.05n

* CHECK dout0_5 Vdout0_5ck44 = 0 time = 450
.meas tran vdout0_5ck44 FIND v(dout0_5) AT=450.05n

* CHECK dout0_6 Vdout0_6ck44 = 0 time = 450
.meas tran vdout0_6ck44 FIND v(dout0_6) AT=450.05n

* CHECK dout0_7 Vdout0_7ck44 = 1.8 time = 450
.meas tran vdout0_7ck44 FIND v(dout0_7) AT=450.05n

* CHECK dout0_8 Vdout0_8ck44 = 0 time = 450
.meas tran vdout0_8ck44 FIND v(dout0_8) AT=450.05n

* CHECK dout0_9 Vdout0_9ck44 = 1.8 time = 450
.meas tran vdout0_9ck44 FIND v(dout0_9) AT=450.05n

* CHECK dout0_10 Vdout0_10ck44 = 1.8 time = 450
.meas tran vdout0_10ck44 FIND v(dout0_10) AT=450.05n

* CHECK dout0_11 Vdout0_11ck44 = 0 time = 450
.meas tran vdout0_11ck44 FIND v(dout0_11) AT=450.05n

* CHECK dout0_12 Vdout0_12ck44 = 1.8 time = 450
.meas tran vdout0_12ck44 FIND v(dout0_12) AT=450.05n

* CHECK dout0_13 Vdout0_13ck44 = 0 time = 450
.meas tran vdout0_13ck44 FIND v(dout0_13) AT=450.05n

* CHECK dout0_14 Vdout0_14ck44 = 0 time = 450
.meas tran vdout0_14ck44 FIND v(dout0_14) AT=450.05n

* CHECK dout0_15 Vdout0_15ck44 = 0 time = 450
.meas tran vdout0_15ck44 FIND v(dout0_15) AT=450.05n

* CHECK dout0_16 Vdout0_16ck44 = 1.8 time = 450
.meas tran vdout0_16ck44 FIND v(dout0_16) AT=450.05n

* CHECK dout0_17 Vdout0_17ck44 = 1.8 time = 450
.meas tran vdout0_17ck44 FIND v(dout0_17) AT=450.05n

* CHECK dout0_18 Vdout0_18ck44 = 1.8 time = 450
.meas tran vdout0_18ck44 FIND v(dout0_18) AT=450.05n

* CHECK dout0_19 Vdout0_19ck44 = 0 time = 450
.meas tran vdout0_19ck44 FIND v(dout0_19) AT=450.05n

* CHECK dout0_20 Vdout0_20ck44 = 0 time = 450
.meas tran vdout0_20ck44 FIND v(dout0_20) AT=450.05n

* CHECK dout0_21 Vdout0_21ck44 = 1.8 time = 450
.meas tran vdout0_21ck44 FIND v(dout0_21) AT=450.05n

* CHECK dout0_22 Vdout0_22ck44 = 0 time = 450
.meas tran vdout0_22ck44 FIND v(dout0_22) AT=450.05n

* CHECK dout0_23 Vdout0_23ck44 = 0 time = 450
.meas tran vdout0_23ck44 FIND v(dout0_23) AT=450.05n

* CHECK dout0_24 Vdout0_24ck44 = 0 time = 450
.meas tran vdout0_24ck44 FIND v(dout0_24) AT=450.05n

* CHECK dout0_25 Vdout0_25ck44 = 1.8 time = 450
.meas tran vdout0_25ck44 FIND v(dout0_25) AT=450.05n

* CHECK dout0_26 Vdout0_26ck44 = 1.8 time = 450
.meas tran vdout0_26ck44 FIND v(dout0_26) AT=450.05n

* CHECK dout0_27 Vdout0_27ck44 = 1.8 time = 450
.meas tran vdout0_27ck44 FIND v(dout0_27) AT=450.05n

* CHECK dout0_28 Vdout0_28ck44 = 0 time = 450
.meas tran vdout0_28ck44 FIND v(dout0_28) AT=450.05n

* CHECK dout0_29 Vdout0_29ck44 = 1.8 time = 450
.meas tran vdout0_29ck44 FIND v(dout0_29) AT=450.05n

* CHECK dout0_30 Vdout0_30ck44 = 0 time = 450
.meas tran vdout0_30ck44 FIND v(dout0_30) AT=450.05n

* CHECK dout0_31 Vdout0_31ck44 = 1.8 time = 450
.meas tran vdout0_31ck44 FIND v(dout0_31) AT=450.05n

* CHECK dout0_32 Vdout0_32ck44 = 0 time = 450
.meas tran vdout0_32ck44 FIND v(dout0_32) AT=450.05n

* CHECK dout0_0 Vdout0_0ck45 = 1.8 time = 460
.meas tran vdout0_0ck45 FIND v(dout0_0) AT=460.05n

* CHECK dout0_1 Vdout0_1ck45 = 0 time = 460
.meas tran vdout0_1ck45 FIND v(dout0_1) AT=460.05n

* CHECK dout0_2 Vdout0_2ck45 = 1.8 time = 460
.meas tran vdout0_2ck45 FIND v(dout0_2) AT=460.05n

* CHECK dout0_3 Vdout0_3ck45 = 0 time = 460
.meas tran vdout0_3ck45 FIND v(dout0_3) AT=460.05n

* CHECK dout0_4 Vdout0_4ck45 = 0 time = 460
.meas tran vdout0_4ck45 FIND v(dout0_4) AT=460.05n

* CHECK dout0_5 Vdout0_5ck45 = 0 time = 460
.meas tran vdout0_5ck45 FIND v(dout0_5) AT=460.05n

* CHECK dout0_6 Vdout0_6ck45 = 0 time = 460
.meas tran vdout0_6ck45 FIND v(dout0_6) AT=460.05n

* CHECK dout0_7 Vdout0_7ck45 = 1.8 time = 460
.meas tran vdout0_7ck45 FIND v(dout0_7) AT=460.05n

* CHECK dout0_8 Vdout0_8ck45 = 0 time = 460
.meas tran vdout0_8ck45 FIND v(dout0_8) AT=460.05n

* CHECK dout0_9 Vdout0_9ck45 = 1.8 time = 460
.meas tran vdout0_9ck45 FIND v(dout0_9) AT=460.05n

* CHECK dout0_10 Vdout0_10ck45 = 1.8 time = 460
.meas tran vdout0_10ck45 FIND v(dout0_10) AT=460.05n

* CHECK dout0_11 Vdout0_11ck45 = 0 time = 460
.meas tran vdout0_11ck45 FIND v(dout0_11) AT=460.05n

* CHECK dout0_12 Vdout0_12ck45 = 1.8 time = 460
.meas tran vdout0_12ck45 FIND v(dout0_12) AT=460.05n

* CHECK dout0_13 Vdout0_13ck45 = 0 time = 460
.meas tran vdout0_13ck45 FIND v(dout0_13) AT=460.05n

* CHECK dout0_14 Vdout0_14ck45 = 0 time = 460
.meas tran vdout0_14ck45 FIND v(dout0_14) AT=460.05n

* CHECK dout0_15 Vdout0_15ck45 = 0 time = 460
.meas tran vdout0_15ck45 FIND v(dout0_15) AT=460.05n

* CHECK dout0_16 Vdout0_16ck45 = 1.8 time = 460
.meas tran vdout0_16ck45 FIND v(dout0_16) AT=460.05n

* CHECK dout0_17 Vdout0_17ck45 = 1.8 time = 460
.meas tran vdout0_17ck45 FIND v(dout0_17) AT=460.05n

* CHECK dout0_18 Vdout0_18ck45 = 1.8 time = 460
.meas tran vdout0_18ck45 FIND v(dout0_18) AT=460.05n

* CHECK dout0_19 Vdout0_19ck45 = 0 time = 460
.meas tran vdout0_19ck45 FIND v(dout0_19) AT=460.05n

* CHECK dout0_20 Vdout0_20ck45 = 0 time = 460
.meas tran vdout0_20ck45 FIND v(dout0_20) AT=460.05n

* CHECK dout0_21 Vdout0_21ck45 = 1.8 time = 460
.meas tran vdout0_21ck45 FIND v(dout0_21) AT=460.05n

* CHECK dout0_22 Vdout0_22ck45 = 0 time = 460
.meas tran vdout0_22ck45 FIND v(dout0_22) AT=460.05n

* CHECK dout0_23 Vdout0_23ck45 = 0 time = 460
.meas tran vdout0_23ck45 FIND v(dout0_23) AT=460.05n

* CHECK dout0_24 Vdout0_24ck45 = 0 time = 460
.meas tran vdout0_24ck45 FIND v(dout0_24) AT=460.05n

* CHECK dout0_25 Vdout0_25ck45 = 1.8 time = 460
.meas tran vdout0_25ck45 FIND v(dout0_25) AT=460.05n

* CHECK dout0_26 Vdout0_26ck45 = 1.8 time = 460
.meas tran vdout0_26ck45 FIND v(dout0_26) AT=460.05n

* CHECK dout0_27 Vdout0_27ck45 = 1.8 time = 460
.meas tran vdout0_27ck45 FIND v(dout0_27) AT=460.05n

* CHECK dout0_28 Vdout0_28ck45 = 0 time = 460
.meas tran vdout0_28ck45 FIND v(dout0_28) AT=460.05n

* CHECK dout0_29 Vdout0_29ck45 = 1.8 time = 460
.meas tran vdout0_29ck45 FIND v(dout0_29) AT=460.05n

* CHECK dout0_30 Vdout0_30ck45 = 0 time = 460
.meas tran vdout0_30ck45 FIND v(dout0_30) AT=460.05n

* CHECK dout0_31 Vdout0_31ck45 = 1.8 time = 460
.meas tran vdout0_31ck45 FIND v(dout0_31) AT=460.05n

* CHECK dout0_32 Vdout0_32ck45 = 0 time = 460
.meas tran vdout0_32ck45 FIND v(dout0_32) AT=460.05n

* CHECK dout0_0 Vdout0_0ck46 = 1.8 time = 470
.meas tran vdout0_0ck46 FIND v(dout0_0) AT=470.05n

* CHECK dout0_1 Vdout0_1ck46 = 0 time = 470
.meas tran vdout0_1ck46 FIND v(dout0_1) AT=470.05n

* CHECK dout0_2 Vdout0_2ck46 = 1.8 time = 470
.meas tran vdout0_2ck46 FIND v(dout0_2) AT=470.05n

* CHECK dout0_3 Vdout0_3ck46 = 0 time = 470
.meas tran vdout0_3ck46 FIND v(dout0_3) AT=470.05n

* CHECK dout0_4 Vdout0_4ck46 = 0 time = 470
.meas tran vdout0_4ck46 FIND v(dout0_4) AT=470.05n

* CHECK dout0_5 Vdout0_5ck46 = 0 time = 470
.meas tran vdout0_5ck46 FIND v(dout0_5) AT=470.05n

* CHECK dout0_6 Vdout0_6ck46 = 0 time = 470
.meas tran vdout0_6ck46 FIND v(dout0_6) AT=470.05n

* CHECK dout0_7 Vdout0_7ck46 = 1.8 time = 470
.meas tran vdout0_7ck46 FIND v(dout0_7) AT=470.05n

* CHECK dout0_8 Vdout0_8ck46 = 0 time = 470
.meas tran vdout0_8ck46 FIND v(dout0_8) AT=470.05n

* CHECK dout0_9 Vdout0_9ck46 = 1.8 time = 470
.meas tran vdout0_9ck46 FIND v(dout0_9) AT=470.05n

* CHECK dout0_10 Vdout0_10ck46 = 1.8 time = 470
.meas tran vdout0_10ck46 FIND v(dout0_10) AT=470.05n

* CHECK dout0_11 Vdout0_11ck46 = 0 time = 470
.meas tran vdout0_11ck46 FIND v(dout0_11) AT=470.05n

* CHECK dout0_12 Vdout0_12ck46 = 1.8 time = 470
.meas tran vdout0_12ck46 FIND v(dout0_12) AT=470.05n

* CHECK dout0_13 Vdout0_13ck46 = 0 time = 470
.meas tran vdout0_13ck46 FIND v(dout0_13) AT=470.05n

* CHECK dout0_14 Vdout0_14ck46 = 0 time = 470
.meas tran vdout0_14ck46 FIND v(dout0_14) AT=470.05n

* CHECK dout0_15 Vdout0_15ck46 = 0 time = 470
.meas tran vdout0_15ck46 FIND v(dout0_15) AT=470.05n

* CHECK dout0_16 Vdout0_16ck46 = 1.8 time = 470
.meas tran vdout0_16ck46 FIND v(dout0_16) AT=470.05n

* CHECK dout0_17 Vdout0_17ck46 = 1.8 time = 470
.meas tran vdout0_17ck46 FIND v(dout0_17) AT=470.05n

* CHECK dout0_18 Vdout0_18ck46 = 1.8 time = 470
.meas tran vdout0_18ck46 FIND v(dout0_18) AT=470.05n

* CHECK dout0_19 Vdout0_19ck46 = 0 time = 470
.meas tran vdout0_19ck46 FIND v(dout0_19) AT=470.05n

* CHECK dout0_20 Vdout0_20ck46 = 0 time = 470
.meas tran vdout0_20ck46 FIND v(dout0_20) AT=470.05n

* CHECK dout0_21 Vdout0_21ck46 = 1.8 time = 470
.meas tran vdout0_21ck46 FIND v(dout0_21) AT=470.05n

* CHECK dout0_22 Vdout0_22ck46 = 0 time = 470
.meas tran vdout0_22ck46 FIND v(dout0_22) AT=470.05n

* CHECK dout0_23 Vdout0_23ck46 = 0 time = 470
.meas tran vdout0_23ck46 FIND v(dout0_23) AT=470.05n

* CHECK dout0_24 Vdout0_24ck46 = 0 time = 470
.meas tran vdout0_24ck46 FIND v(dout0_24) AT=470.05n

* CHECK dout0_25 Vdout0_25ck46 = 1.8 time = 470
.meas tran vdout0_25ck46 FIND v(dout0_25) AT=470.05n

* CHECK dout0_26 Vdout0_26ck46 = 1.8 time = 470
.meas tran vdout0_26ck46 FIND v(dout0_26) AT=470.05n

* CHECK dout0_27 Vdout0_27ck46 = 1.8 time = 470
.meas tran vdout0_27ck46 FIND v(dout0_27) AT=470.05n

* CHECK dout0_28 Vdout0_28ck46 = 0 time = 470
.meas tran vdout0_28ck46 FIND v(dout0_28) AT=470.05n

* CHECK dout0_29 Vdout0_29ck46 = 1.8 time = 470
.meas tran vdout0_29ck46 FIND v(dout0_29) AT=470.05n

* CHECK dout0_30 Vdout0_30ck46 = 0 time = 470
.meas tran vdout0_30ck46 FIND v(dout0_30) AT=470.05n

* CHECK dout0_31 Vdout0_31ck46 = 1.8 time = 470
.meas tran vdout0_31ck46 FIND v(dout0_31) AT=470.05n

* CHECK dout0_32 Vdout0_32ck46 = 0 time = 470
.meas tran vdout0_32ck46 FIND v(dout0_32) AT=470.05n

* CHECK dout0_0 Vdout0_0ck47 = 1.8 time = 480
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=480.05n

* CHECK dout0_1 Vdout0_1ck47 = 0 time = 480
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=480.05n

* CHECK dout0_2 Vdout0_2ck47 = 1.8 time = 480
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=480.05n

* CHECK dout0_3 Vdout0_3ck47 = 1.8 time = 480
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=480.05n

* CHECK dout0_4 Vdout0_4ck47 = 0 time = 480
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=480.05n

* CHECK dout0_5 Vdout0_5ck47 = 1.8 time = 480
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=480.05n

* CHECK dout0_6 Vdout0_6ck47 = 1.8 time = 480
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=480.05n

* CHECK dout0_7 Vdout0_7ck47 = 0 time = 480
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=480.05n

* CHECK dout0_8 Vdout0_8ck47 = 0 time = 480
.meas tran vdout0_8ck47 FIND v(dout0_8) AT=480.05n

* CHECK dout0_9 Vdout0_9ck47 = 0 time = 480
.meas tran vdout0_9ck47 FIND v(dout0_9) AT=480.05n

* CHECK dout0_10 Vdout0_10ck47 = 0 time = 480
.meas tran vdout0_10ck47 FIND v(dout0_10) AT=480.05n

* CHECK dout0_11 Vdout0_11ck47 = 0 time = 480
.meas tran vdout0_11ck47 FIND v(dout0_11) AT=480.05n

* CHECK dout0_12 Vdout0_12ck47 = 0 time = 480
.meas tran vdout0_12ck47 FIND v(dout0_12) AT=480.05n

* CHECK dout0_13 Vdout0_13ck47 = 0 time = 480
.meas tran vdout0_13ck47 FIND v(dout0_13) AT=480.05n

* CHECK dout0_14 Vdout0_14ck47 = 0 time = 480
.meas tran vdout0_14ck47 FIND v(dout0_14) AT=480.05n

* CHECK dout0_15 Vdout0_15ck47 = 1.8 time = 480
.meas tran vdout0_15ck47 FIND v(dout0_15) AT=480.05n

* CHECK dout0_16 Vdout0_16ck47 = 1.8 time = 480
.meas tran vdout0_16ck47 FIND v(dout0_16) AT=480.05n

* CHECK dout0_17 Vdout0_17ck47 = 1.8 time = 480
.meas tran vdout0_17ck47 FIND v(dout0_17) AT=480.05n

* CHECK dout0_18 Vdout0_18ck47 = 1.8 time = 480
.meas tran vdout0_18ck47 FIND v(dout0_18) AT=480.05n

* CHECK dout0_19 Vdout0_19ck47 = 0 time = 480
.meas tran vdout0_19ck47 FIND v(dout0_19) AT=480.05n

* CHECK dout0_20 Vdout0_20ck47 = 1.8 time = 480
.meas tran vdout0_20ck47 FIND v(dout0_20) AT=480.05n

* CHECK dout0_21 Vdout0_21ck47 = 0 time = 480
.meas tran vdout0_21ck47 FIND v(dout0_21) AT=480.05n

* CHECK dout0_22 Vdout0_22ck47 = 1.8 time = 480
.meas tran vdout0_22ck47 FIND v(dout0_22) AT=480.05n

* CHECK dout0_23 Vdout0_23ck47 = 1.8 time = 480
.meas tran vdout0_23ck47 FIND v(dout0_23) AT=480.05n

* CHECK dout0_24 Vdout0_24ck47 = 0 time = 480
.meas tran vdout0_24ck47 FIND v(dout0_24) AT=480.05n

* CHECK dout0_25 Vdout0_25ck47 = 0 time = 480
.meas tran vdout0_25ck47 FIND v(dout0_25) AT=480.05n

* CHECK dout0_26 Vdout0_26ck47 = 1.8 time = 480
.meas tran vdout0_26ck47 FIND v(dout0_26) AT=480.05n

* CHECK dout0_27 Vdout0_27ck47 = 0 time = 480
.meas tran vdout0_27ck47 FIND v(dout0_27) AT=480.05n

* CHECK dout0_28 Vdout0_28ck47 = 1.8 time = 480
.meas tran vdout0_28ck47 FIND v(dout0_28) AT=480.05n

* CHECK dout0_29 Vdout0_29ck47 = 1.8 time = 480
.meas tran vdout0_29ck47 FIND v(dout0_29) AT=480.05n

* CHECK dout0_30 Vdout0_30ck47 = 0 time = 480
.meas tran vdout0_30ck47 FIND v(dout0_30) AT=480.05n

* CHECK dout0_31 Vdout0_31ck47 = 0 time = 480
.meas tran vdout0_31ck47 FIND v(dout0_31) AT=480.05n

* CHECK dout0_32 Vdout0_32ck47 = 0 time = 480
.meas tran vdout0_32ck47 FIND v(dout0_32) AT=480.05n

* CHECK dout0_0 Vdout0_0ck50 = 1.8 time = 510
.meas tran vdout0_0ck50 FIND v(dout0_0) AT=510.05n

* CHECK dout0_1 Vdout0_1ck50 = 0 time = 510
.meas tran vdout0_1ck50 FIND v(dout0_1) AT=510.05n

* CHECK dout0_2 Vdout0_2ck50 = 1.8 time = 510
.meas tran vdout0_2ck50 FIND v(dout0_2) AT=510.05n

* CHECK dout0_3 Vdout0_3ck50 = 0 time = 510
.meas tran vdout0_3ck50 FIND v(dout0_3) AT=510.05n

* CHECK dout0_4 Vdout0_4ck50 = 0 time = 510
.meas tran vdout0_4ck50 FIND v(dout0_4) AT=510.05n

* CHECK dout0_5 Vdout0_5ck50 = 0 time = 510
.meas tran vdout0_5ck50 FIND v(dout0_5) AT=510.05n

* CHECK dout0_6 Vdout0_6ck50 = 0 time = 510
.meas tran vdout0_6ck50 FIND v(dout0_6) AT=510.05n

* CHECK dout0_7 Vdout0_7ck50 = 1.8 time = 510
.meas tran vdout0_7ck50 FIND v(dout0_7) AT=510.05n

* CHECK dout0_8 Vdout0_8ck50 = 0 time = 510
.meas tran vdout0_8ck50 FIND v(dout0_8) AT=510.05n

* CHECK dout0_9 Vdout0_9ck50 = 1.8 time = 510
.meas tran vdout0_9ck50 FIND v(dout0_9) AT=510.05n

* CHECK dout0_10 Vdout0_10ck50 = 1.8 time = 510
.meas tran vdout0_10ck50 FIND v(dout0_10) AT=510.05n

* CHECK dout0_11 Vdout0_11ck50 = 0 time = 510
.meas tran vdout0_11ck50 FIND v(dout0_11) AT=510.05n

* CHECK dout0_12 Vdout0_12ck50 = 1.8 time = 510
.meas tran vdout0_12ck50 FIND v(dout0_12) AT=510.05n

* CHECK dout0_13 Vdout0_13ck50 = 0 time = 510
.meas tran vdout0_13ck50 FIND v(dout0_13) AT=510.05n

* CHECK dout0_14 Vdout0_14ck50 = 0 time = 510
.meas tran vdout0_14ck50 FIND v(dout0_14) AT=510.05n

* CHECK dout0_15 Vdout0_15ck50 = 0 time = 510
.meas tran vdout0_15ck50 FIND v(dout0_15) AT=510.05n

* CHECK dout0_16 Vdout0_16ck50 = 1.8 time = 510
.meas tran vdout0_16ck50 FIND v(dout0_16) AT=510.05n

* CHECK dout0_17 Vdout0_17ck50 = 1.8 time = 510
.meas tran vdout0_17ck50 FIND v(dout0_17) AT=510.05n

* CHECK dout0_18 Vdout0_18ck50 = 1.8 time = 510
.meas tran vdout0_18ck50 FIND v(dout0_18) AT=510.05n

* CHECK dout0_19 Vdout0_19ck50 = 0 time = 510
.meas tran vdout0_19ck50 FIND v(dout0_19) AT=510.05n

* CHECK dout0_20 Vdout0_20ck50 = 0 time = 510
.meas tran vdout0_20ck50 FIND v(dout0_20) AT=510.05n

* CHECK dout0_21 Vdout0_21ck50 = 1.8 time = 510
.meas tran vdout0_21ck50 FIND v(dout0_21) AT=510.05n

* CHECK dout0_22 Vdout0_22ck50 = 0 time = 510
.meas tran vdout0_22ck50 FIND v(dout0_22) AT=510.05n

* CHECK dout0_23 Vdout0_23ck50 = 0 time = 510
.meas tran vdout0_23ck50 FIND v(dout0_23) AT=510.05n

* CHECK dout0_24 Vdout0_24ck50 = 0 time = 510
.meas tran vdout0_24ck50 FIND v(dout0_24) AT=510.05n

* CHECK dout0_25 Vdout0_25ck50 = 1.8 time = 510
.meas tran vdout0_25ck50 FIND v(dout0_25) AT=510.05n

* CHECK dout0_26 Vdout0_26ck50 = 1.8 time = 510
.meas tran vdout0_26ck50 FIND v(dout0_26) AT=510.05n

* CHECK dout0_27 Vdout0_27ck50 = 1.8 time = 510
.meas tran vdout0_27ck50 FIND v(dout0_27) AT=510.05n

* CHECK dout0_28 Vdout0_28ck50 = 0 time = 510
.meas tran vdout0_28ck50 FIND v(dout0_28) AT=510.05n

* CHECK dout0_29 Vdout0_29ck50 = 1.8 time = 510
.meas tran vdout0_29ck50 FIND v(dout0_29) AT=510.05n

* CHECK dout0_30 Vdout0_30ck50 = 0 time = 510
.meas tran vdout0_30ck50 FIND v(dout0_30) AT=510.05n

* CHECK dout0_31 Vdout0_31ck50 = 1.8 time = 510
.meas tran vdout0_31ck50 FIND v(dout0_31) AT=510.05n

* CHECK dout0_32 Vdout0_32ck50 = 0 time = 510
.meas tran vdout0_32ck50 FIND v(dout0_32) AT=510.05n

* CHECK dout0_0 Vdout0_0ck54 = 1.8 time = 550
.meas tran vdout0_0ck54 FIND v(dout0_0) AT=550.05n

* CHECK dout0_1 Vdout0_1ck54 = 0 time = 550
.meas tran vdout0_1ck54 FIND v(dout0_1) AT=550.05n

* CHECK dout0_2 Vdout0_2ck54 = 1.8 time = 550
.meas tran vdout0_2ck54 FIND v(dout0_2) AT=550.05n

* CHECK dout0_3 Vdout0_3ck54 = 1.8 time = 550
.meas tran vdout0_3ck54 FIND v(dout0_3) AT=550.05n

* CHECK dout0_4 Vdout0_4ck54 = 1.8 time = 550
.meas tran vdout0_4ck54 FIND v(dout0_4) AT=550.05n

* CHECK dout0_5 Vdout0_5ck54 = 1.8 time = 550
.meas tran vdout0_5ck54 FIND v(dout0_5) AT=550.05n

* CHECK dout0_6 Vdout0_6ck54 = 0 time = 550
.meas tran vdout0_6ck54 FIND v(dout0_6) AT=550.05n

* CHECK dout0_7 Vdout0_7ck54 = 1.8 time = 550
.meas tran vdout0_7ck54 FIND v(dout0_7) AT=550.05n

* CHECK dout0_8 Vdout0_8ck54 = 0 time = 550
.meas tran vdout0_8ck54 FIND v(dout0_8) AT=550.05n

* CHECK dout0_9 Vdout0_9ck54 = 1.8 time = 550
.meas tran vdout0_9ck54 FIND v(dout0_9) AT=550.05n

* CHECK dout0_10 Vdout0_10ck54 = 0 time = 550
.meas tran vdout0_10ck54 FIND v(dout0_10) AT=550.05n

* CHECK dout0_11 Vdout0_11ck54 = 1.8 time = 550
.meas tran vdout0_11ck54 FIND v(dout0_11) AT=550.05n

* CHECK dout0_12 Vdout0_12ck54 = 0 time = 550
.meas tran vdout0_12ck54 FIND v(dout0_12) AT=550.05n

* CHECK dout0_13 Vdout0_13ck54 = 0 time = 550
.meas tran vdout0_13ck54 FIND v(dout0_13) AT=550.05n

* CHECK dout0_14 Vdout0_14ck54 = 0 time = 550
.meas tran vdout0_14ck54 FIND v(dout0_14) AT=550.05n

* CHECK dout0_15 Vdout0_15ck54 = 0 time = 550
.meas tran vdout0_15ck54 FIND v(dout0_15) AT=550.05n

* CHECK dout0_16 Vdout0_16ck54 = 1.8 time = 550
.meas tran vdout0_16ck54 FIND v(dout0_16) AT=550.05n

* CHECK dout0_17 Vdout0_17ck54 = 1.8 time = 550
.meas tran vdout0_17ck54 FIND v(dout0_17) AT=550.05n

* CHECK dout0_18 Vdout0_18ck54 = 1.8 time = 550
.meas tran vdout0_18ck54 FIND v(dout0_18) AT=550.05n

* CHECK dout0_19 Vdout0_19ck54 = 0 time = 550
.meas tran vdout0_19ck54 FIND v(dout0_19) AT=550.05n

* CHECK dout0_20 Vdout0_20ck54 = 0 time = 550
.meas tran vdout0_20ck54 FIND v(dout0_20) AT=550.05n

* CHECK dout0_21 Vdout0_21ck54 = 1.8 time = 550
.meas tran vdout0_21ck54 FIND v(dout0_21) AT=550.05n

* CHECK dout0_22 Vdout0_22ck54 = 1.8 time = 550
.meas tran vdout0_22ck54 FIND v(dout0_22) AT=550.05n

* CHECK dout0_23 Vdout0_23ck54 = 1.8 time = 550
.meas tran vdout0_23ck54 FIND v(dout0_23) AT=550.05n

* CHECK dout0_24 Vdout0_24ck54 = 0 time = 550
.meas tran vdout0_24ck54 FIND v(dout0_24) AT=550.05n

* CHECK dout0_25 Vdout0_25ck54 = 1.8 time = 550
.meas tran vdout0_25ck54 FIND v(dout0_25) AT=550.05n

* CHECK dout0_26 Vdout0_26ck54 = 0 time = 550
.meas tran vdout0_26ck54 FIND v(dout0_26) AT=550.05n

* CHECK dout0_27 Vdout0_27ck54 = 0 time = 550
.meas tran vdout0_27ck54 FIND v(dout0_27) AT=550.05n

* CHECK dout0_28 Vdout0_28ck54 = 1.8 time = 550
.meas tran vdout0_28ck54 FIND v(dout0_28) AT=550.05n

* CHECK dout0_29 Vdout0_29ck54 = 1.8 time = 550
.meas tran vdout0_29ck54 FIND v(dout0_29) AT=550.05n

* CHECK dout0_30 Vdout0_30ck54 = 0 time = 550
.meas tran vdout0_30ck54 FIND v(dout0_30) AT=550.05n

* CHECK dout0_31 Vdout0_31ck54 = 0 time = 550
.meas tran vdout0_31ck54 FIND v(dout0_31) AT=550.05n

* CHECK dout0_32 Vdout0_32ck54 = 0 time = 550
.meas tran vdout0_32ck54 FIND v(dout0_32) AT=550.05n

* CHECK dout0_0 Vdout0_0ck58 = 0 time = 590
.meas tran vdout0_0ck58 FIND v(dout0_0) AT=590.05n

* CHECK dout0_1 Vdout0_1ck58 = 1.8 time = 590
.meas tran vdout0_1ck58 FIND v(dout0_1) AT=590.05n

* CHECK dout0_2 Vdout0_2ck58 = 0 time = 590
.meas tran vdout0_2ck58 FIND v(dout0_2) AT=590.05n

* CHECK dout0_3 Vdout0_3ck58 = 0 time = 590
.meas tran vdout0_3ck58 FIND v(dout0_3) AT=590.05n

* CHECK dout0_4 Vdout0_4ck58 = 0 time = 590
.meas tran vdout0_4ck58 FIND v(dout0_4) AT=590.05n

* CHECK dout0_5 Vdout0_5ck58 = 1.8 time = 590
.meas tran vdout0_5ck58 FIND v(dout0_5) AT=590.05n

* CHECK dout0_6 Vdout0_6ck58 = 0 time = 590
.meas tran vdout0_6ck58 FIND v(dout0_6) AT=590.05n

* CHECK dout0_7 Vdout0_7ck58 = 1.8 time = 590
.meas tran vdout0_7ck58 FIND v(dout0_7) AT=590.05n

* CHECK dout0_8 Vdout0_8ck58 = 1.8 time = 590
.meas tran vdout0_8ck58 FIND v(dout0_8) AT=590.05n

* CHECK dout0_9 Vdout0_9ck58 = 1.8 time = 590
.meas tran vdout0_9ck58 FIND v(dout0_9) AT=590.05n

* CHECK dout0_10 Vdout0_10ck58 = 0 time = 590
.meas tran vdout0_10ck58 FIND v(dout0_10) AT=590.05n

* CHECK dout0_11 Vdout0_11ck58 = 1.8 time = 590
.meas tran vdout0_11ck58 FIND v(dout0_11) AT=590.05n

* CHECK dout0_12 Vdout0_12ck58 = 1.8 time = 590
.meas tran vdout0_12ck58 FIND v(dout0_12) AT=590.05n

* CHECK dout0_13 Vdout0_13ck58 = 1.8 time = 590
.meas tran vdout0_13ck58 FIND v(dout0_13) AT=590.05n

* CHECK dout0_14 Vdout0_14ck58 = 0 time = 590
.meas tran vdout0_14ck58 FIND v(dout0_14) AT=590.05n

* CHECK dout0_15 Vdout0_15ck58 = 0 time = 590
.meas tran vdout0_15ck58 FIND v(dout0_15) AT=590.05n

* CHECK dout0_16 Vdout0_16ck58 = 0 time = 590
.meas tran vdout0_16ck58 FIND v(dout0_16) AT=590.05n

* CHECK dout0_17 Vdout0_17ck58 = 0 time = 590
.meas tran vdout0_17ck58 FIND v(dout0_17) AT=590.05n

* CHECK dout0_18 Vdout0_18ck58 = 1.8 time = 590
.meas tran vdout0_18ck58 FIND v(dout0_18) AT=590.05n

* CHECK dout0_19 Vdout0_19ck58 = 1.8 time = 590
.meas tran vdout0_19ck58 FIND v(dout0_19) AT=590.05n

* CHECK dout0_20 Vdout0_20ck58 = 1.8 time = 590
.meas tran vdout0_20ck58 FIND v(dout0_20) AT=590.05n

* CHECK dout0_21 Vdout0_21ck58 = 1.8 time = 590
.meas tran vdout0_21ck58 FIND v(dout0_21) AT=590.05n

* CHECK dout0_22 Vdout0_22ck58 = 1.8 time = 590
.meas tran vdout0_22ck58 FIND v(dout0_22) AT=590.05n

* CHECK dout0_23 Vdout0_23ck58 = 1.8 time = 590
.meas tran vdout0_23ck58 FIND v(dout0_23) AT=590.05n

* CHECK dout0_24 Vdout0_24ck58 = 0 time = 590
.meas tran vdout0_24ck58 FIND v(dout0_24) AT=590.05n

* CHECK dout0_25 Vdout0_25ck58 = 0 time = 590
.meas tran vdout0_25ck58 FIND v(dout0_25) AT=590.05n

* CHECK dout0_26 Vdout0_26ck58 = 0 time = 590
.meas tran vdout0_26ck58 FIND v(dout0_26) AT=590.05n

* CHECK dout0_27 Vdout0_27ck58 = 1.8 time = 590
.meas tran vdout0_27ck58 FIND v(dout0_27) AT=590.05n

* CHECK dout0_28 Vdout0_28ck58 = 0 time = 590
.meas tran vdout0_28ck58 FIND v(dout0_28) AT=590.05n

* CHECK dout0_29 Vdout0_29ck58 = 0 time = 590
.meas tran vdout0_29ck58 FIND v(dout0_29) AT=590.05n

* CHECK dout0_30 Vdout0_30ck58 = 1.8 time = 590
.meas tran vdout0_30ck58 FIND v(dout0_30) AT=590.05n

* CHECK dout0_31 Vdout0_31ck58 = 1.8 time = 590
.meas tran vdout0_31ck58 FIND v(dout0_31) AT=590.05n

* CHECK dout0_32 Vdout0_32ck58 = 0 time = 590
.meas tran vdout0_32ck58 FIND v(dout0_32) AT=590.05n

* CHECK dout0_0 Vdout0_0ck61 = 1.8 time = 620
.meas tran vdout0_0ck61 FIND v(dout0_0) AT=620.05n

* CHECK dout0_1 Vdout0_1ck61 = 0 time = 620
.meas tran vdout0_1ck61 FIND v(dout0_1) AT=620.05n

* CHECK dout0_2 Vdout0_2ck61 = 1.8 time = 620
.meas tran vdout0_2ck61 FIND v(dout0_2) AT=620.05n

* CHECK dout0_3 Vdout0_3ck61 = 1.8 time = 620
.meas tran vdout0_3ck61 FIND v(dout0_3) AT=620.05n

* CHECK dout0_4 Vdout0_4ck61 = 1.8 time = 620
.meas tran vdout0_4ck61 FIND v(dout0_4) AT=620.05n

* CHECK dout0_5 Vdout0_5ck61 = 1.8 time = 620
.meas tran vdout0_5ck61 FIND v(dout0_5) AT=620.05n

* CHECK dout0_6 Vdout0_6ck61 = 0 time = 620
.meas tran vdout0_6ck61 FIND v(dout0_6) AT=620.05n

* CHECK dout0_7 Vdout0_7ck61 = 1.8 time = 620
.meas tran vdout0_7ck61 FIND v(dout0_7) AT=620.05n

* CHECK dout0_8 Vdout0_8ck61 = 0 time = 620
.meas tran vdout0_8ck61 FIND v(dout0_8) AT=620.05n

* CHECK dout0_9 Vdout0_9ck61 = 1.8 time = 620
.meas tran vdout0_9ck61 FIND v(dout0_9) AT=620.05n

* CHECK dout0_10 Vdout0_10ck61 = 0 time = 620
.meas tran vdout0_10ck61 FIND v(dout0_10) AT=620.05n

* CHECK dout0_11 Vdout0_11ck61 = 1.8 time = 620
.meas tran vdout0_11ck61 FIND v(dout0_11) AT=620.05n

* CHECK dout0_12 Vdout0_12ck61 = 0 time = 620
.meas tran vdout0_12ck61 FIND v(dout0_12) AT=620.05n

* CHECK dout0_13 Vdout0_13ck61 = 0 time = 620
.meas tran vdout0_13ck61 FIND v(dout0_13) AT=620.05n

* CHECK dout0_14 Vdout0_14ck61 = 0 time = 620
.meas tran vdout0_14ck61 FIND v(dout0_14) AT=620.05n

* CHECK dout0_15 Vdout0_15ck61 = 0 time = 620
.meas tran vdout0_15ck61 FIND v(dout0_15) AT=620.05n

* CHECK dout0_16 Vdout0_16ck61 = 1.8 time = 620
.meas tran vdout0_16ck61 FIND v(dout0_16) AT=620.05n

* CHECK dout0_17 Vdout0_17ck61 = 1.8 time = 620
.meas tran vdout0_17ck61 FIND v(dout0_17) AT=620.05n

* CHECK dout0_18 Vdout0_18ck61 = 1.8 time = 620
.meas tran vdout0_18ck61 FIND v(dout0_18) AT=620.05n

* CHECK dout0_19 Vdout0_19ck61 = 0 time = 620
.meas tran vdout0_19ck61 FIND v(dout0_19) AT=620.05n

* CHECK dout0_20 Vdout0_20ck61 = 0 time = 620
.meas tran vdout0_20ck61 FIND v(dout0_20) AT=620.05n

* CHECK dout0_21 Vdout0_21ck61 = 1.8 time = 620
.meas tran vdout0_21ck61 FIND v(dout0_21) AT=620.05n

* CHECK dout0_22 Vdout0_22ck61 = 1.8 time = 620
.meas tran vdout0_22ck61 FIND v(dout0_22) AT=620.05n

* CHECK dout0_23 Vdout0_23ck61 = 1.8 time = 620
.meas tran vdout0_23ck61 FIND v(dout0_23) AT=620.05n

* CHECK dout0_24 Vdout0_24ck61 = 0 time = 620
.meas tran vdout0_24ck61 FIND v(dout0_24) AT=620.05n

* CHECK dout0_25 Vdout0_25ck61 = 1.8 time = 620
.meas tran vdout0_25ck61 FIND v(dout0_25) AT=620.05n

* CHECK dout0_26 Vdout0_26ck61 = 0 time = 620
.meas tran vdout0_26ck61 FIND v(dout0_26) AT=620.05n

* CHECK dout0_27 Vdout0_27ck61 = 0 time = 620
.meas tran vdout0_27ck61 FIND v(dout0_27) AT=620.05n

* CHECK dout0_28 Vdout0_28ck61 = 1.8 time = 620
.meas tran vdout0_28ck61 FIND v(dout0_28) AT=620.05n

* CHECK dout0_29 Vdout0_29ck61 = 1.8 time = 620
.meas tran vdout0_29ck61 FIND v(dout0_29) AT=620.05n

* CHECK dout0_30 Vdout0_30ck61 = 0 time = 620
.meas tran vdout0_30ck61 FIND v(dout0_30) AT=620.05n

* CHECK dout0_31 Vdout0_31ck61 = 0 time = 620
.meas tran vdout0_31ck61 FIND v(dout0_31) AT=620.05n

* CHECK dout0_32 Vdout0_32ck61 = 0 time = 620
.meas tran vdout0_32ck61 FIND v(dout0_32) AT=620.05n

* CHECK dout0_0 Vdout0_0ck63 = 1.8 time = 640
.meas tran vdout0_0ck63 FIND v(dout0_0) AT=640.05n

* CHECK dout0_1 Vdout0_1ck63 = 1.8 time = 640
.meas tran vdout0_1ck63 FIND v(dout0_1) AT=640.05n

* CHECK dout0_2 Vdout0_2ck63 = 0 time = 640
.meas tran vdout0_2ck63 FIND v(dout0_2) AT=640.05n

* CHECK dout0_3 Vdout0_3ck63 = 1.8 time = 640
.meas tran vdout0_3ck63 FIND v(dout0_3) AT=640.05n

* CHECK dout0_4 Vdout0_4ck63 = 0 time = 640
.meas tran vdout0_4ck63 FIND v(dout0_4) AT=640.05n

* CHECK dout0_5 Vdout0_5ck63 = 0 time = 640
.meas tran vdout0_5ck63 FIND v(dout0_5) AT=640.05n

* CHECK dout0_6 Vdout0_6ck63 = 1.8 time = 640
.meas tran vdout0_6ck63 FIND v(dout0_6) AT=640.05n

* CHECK dout0_7 Vdout0_7ck63 = 0 time = 640
.meas tran vdout0_7ck63 FIND v(dout0_7) AT=640.05n

* CHECK dout0_8 Vdout0_8ck63 = 0 time = 640
.meas tran vdout0_8ck63 FIND v(dout0_8) AT=640.05n

* CHECK dout0_9 Vdout0_9ck63 = 1.8 time = 640
.meas tran vdout0_9ck63 FIND v(dout0_9) AT=640.05n

* CHECK dout0_10 Vdout0_10ck63 = 1.8 time = 640
.meas tran vdout0_10ck63 FIND v(dout0_10) AT=640.05n

* CHECK dout0_11 Vdout0_11ck63 = 1.8 time = 640
.meas tran vdout0_11ck63 FIND v(dout0_11) AT=640.05n

* CHECK dout0_12 Vdout0_12ck63 = 1.8 time = 640
.meas tran vdout0_12ck63 FIND v(dout0_12) AT=640.05n

* CHECK dout0_13 Vdout0_13ck63 = 0 time = 640
.meas tran vdout0_13ck63 FIND v(dout0_13) AT=640.05n

* CHECK dout0_14 Vdout0_14ck63 = 1.8 time = 640
.meas tran vdout0_14ck63 FIND v(dout0_14) AT=640.05n

* CHECK dout0_15 Vdout0_15ck63 = 1.8 time = 640
.meas tran vdout0_15ck63 FIND v(dout0_15) AT=640.05n

* CHECK dout0_16 Vdout0_16ck63 = 0 time = 640
.meas tran vdout0_16ck63 FIND v(dout0_16) AT=640.05n

* CHECK dout0_17 Vdout0_17ck63 = 1.8 time = 640
.meas tran vdout0_17ck63 FIND v(dout0_17) AT=640.05n

* CHECK dout0_18 Vdout0_18ck63 = 0 time = 640
.meas tran vdout0_18ck63 FIND v(dout0_18) AT=640.05n

* CHECK dout0_19 Vdout0_19ck63 = 1.8 time = 640
.meas tran vdout0_19ck63 FIND v(dout0_19) AT=640.05n

* CHECK dout0_20 Vdout0_20ck63 = 1.8 time = 640
.meas tran vdout0_20ck63 FIND v(dout0_20) AT=640.05n

* CHECK dout0_21 Vdout0_21ck63 = 1.8 time = 640
.meas tran vdout0_21ck63 FIND v(dout0_21) AT=640.05n

* CHECK dout0_22 Vdout0_22ck63 = 1.8 time = 640
.meas tran vdout0_22ck63 FIND v(dout0_22) AT=640.05n

* CHECK dout0_23 Vdout0_23ck63 = 0 time = 640
.meas tran vdout0_23ck63 FIND v(dout0_23) AT=640.05n

* CHECK dout0_24 Vdout0_24ck63 = 0 time = 640
.meas tran vdout0_24ck63 FIND v(dout0_24) AT=640.05n

* CHECK dout0_25 Vdout0_25ck63 = 1.8 time = 640
.meas tran vdout0_25ck63 FIND v(dout0_25) AT=640.05n

* CHECK dout0_26 Vdout0_26ck63 = 0 time = 640
.meas tran vdout0_26ck63 FIND v(dout0_26) AT=640.05n

* CHECK dout0_27 Vdout0_27ck63 = 1.8 time = 640
.meas tran vdout0_27ck63 FIND v(dout0_27) AT=640.05n

* CHECK dout0_28 Vdout0_28ck63 = 1.8 time = 640
.meas tran vdout0_28ck63 FIND v(dout0_28) AT=640.05n

* CHECK dout0_29 Vdout0_29ck63 = 0 time = 640
.meas tran vdout0_29ck63 FIND v(dout0_29) AT=640.05n

* CHECK dout0_30 Vdout0_30ck63 = 1.8 time = 640
.meas tran vdout0_30ck63 FIND v(dout0_30) AT=640.05n

* CHECK dout0_31 Vdout0_31ck63 = 1.8 time = 640
.meas tran vdout0_31ck63 FIND v(dout0_31) AT=640.05n

* CHECK dout0_32 Vdout0_32ck63 = 0 time = 640
.meas tran vdout0_32ck63 FIND v(dout0_32) AT=640.05n

* CHECK dout0_0 Vdout0_0ck64 = 1.8 time = 650
.meas tran vdout0_0ck64 FIND v(dout0_0) AT=650.05n

* CHECK dout0_1 Vdout0_1ck64 = 0 time = 650
.meas tran vdout0_1ck64 FIND v(dout0_1) AT=650.05n

* CHECK dout0_2 Vdout0_2ck64 = 1.8 time = 650
.meas tran vdout0_2ck64 FIND v(dout0_2) AT=650.05n

* CHECK dout0_3 Vdout0_3ck64 = 1.8 time = 650
.meas tran vdout0_3ck64 FIND v(dout0_3) AT=650.05n

* CHECK dout0_4 Vdout0_4ck64 = 1.8 time = 650
.meas tran vdout0_4ck64 FIND v(dout0_4) AT=650.05n

* CHECK dout0_5 Vdout0_5ck64 = 1.8 time = 650
.meas tran vdout0_5ck64 FIND v(dout0_5) AT=650.05n

* CHECK dout0_6 Vdout0_6ck64 = 0 time = 650
.meas tran vdout0_6ck64 FIND v(dout0_6) AT=650.05n

* CHECK dout0_7 Vdout0_7ck64 = 1.8 time = 650
.meas tran vdout0_7ck64 FIND v(dout0_7) AT=650.05n

* CHECK dout0_8 Vdout0_8ck64 = 0 time = 650
.meas tran vdout0_8ck64 FIND v(dout0_8) AT=650.05n

* CHECK dout0_9 Vdout0_9ck64 = 1.8 time = 650
.meas tran vdout0_9ck64 FIND v(dout0_9) AT=650.05n

* CHECK dout0_10 Vdout0_10ck64 = 0 time = 650
.meas tran vdout0_10ck64 FIND v(dout0_10) AT=650.05n

* CHECK dout0_11 Vdout0_11ck64 = 1.8 time = 650
.meas tran vdout0_11ck64 FIND v(dout0_11) AT=650.05n

* CHECK dout0_12 Vdout0_12ck64 = 0 time = 650
.meas tran vdout0_12ck64 FIND v(dout0_12) AT=650.05n

* CHECK dout0_13 Vdout0_13ck64 = 0 time = 650
.meas tran vdout0_13ck64 FIND v(dout0_13) AT=650.05n

* CHECK dout0_14 Vdout0_14ck64 = 0 time = 650
.meas tran vdout0_14ck64 FIND v(dout0_14) AT=650.05n

* CHECK dout0_15 Vdout0_15ck64 = 0 time = 650
.meas tran vdout0_15ck64 FIND v(dout0_15) AT=650.05n

* CHECK dout0_16 Vdout0_16ck64 = 1.8 time = 650
.meas tran vdout0_16ck64 FIND v(dout0_16) AT=650.05n

* CHECK dout0_17 Vdout0_17ck64 = 1.8 time = 650
.meas tran vdout0_17ck64 FIND v(dout0_17) AT=650.05n

* CHECK dout0_18 Vdout0_18ck64 = 1.8 time = 650
.meas tran vdout0_18ck64 FIND v(dout0_18) AT=650.05n

* CHECK dout0_19 Vdout0_19ck64 = 0 time = 650
.meas tran vdout0_19ck64 FIND v(dout0_19) AT=650.05n

* CHECK dout0_20 Vdout0_20ck64 = 0 time = 650
.meas tran vdout0_20ck64 FIND v(dout0_20) AT=650.05n

* CHECK dout0_21 Vdout0_21ck64 = 1.8 time = 650
.meas tran vdout0_21ck64 FIND v(dout0_21) AT=650.05n

* CHECK dout0_22 Vdout0_22ck64 = 1.8 time = 650
.meas tran vdout0_22ck64 FIND v(dout0_22) AT=650.05n

* CHECK dout0_23 Vdout0_23ck64 = 1.8 time = 650
.meas tran vdout0_23ck64 FIND v(dout0_23) AT=650.05n

* CHECK dout0_24 Vdout0_24ck64 = 0 time = 650
.meas tran vdout0_24ck64 FIND v(dout0_24) AT=650.05n

* CHECK dout0_25 Vdout0_25ck64 = 1.8 time = 650
.meas tran vdout0_25ck64 FIND v(dout0_25) AT=650.05n

* CHECK dout0_26 Vdout0_26ck64 = 0 time = 650
.meas tran vdout0_26ck64 FIND v(dout0_26) AT=650.05n

* CHECK dout0_27 Vdout0_27ck64 = 0 time = 650
.meas tran vdout0_27ck64 FIND v(dout0_27) AT=650.05n

* CHECK dout0_28 Vdout0_28ck64 = 1.8 time = 650
.meas tran vdout0_28ck64 FIND v(dout0_28) AT=650.05n

* CHECK dout0_29 Vdout0_29ck64 = 1.8 time = 650
.meas tran vdout0_29ck64 FIND v(dout0_29) AT=650.05n

* CHECK dout0_30 Vdout0_30ck64 = 0 time = 650
.meas tran vdout0_30ck64 FIND v(dout0_30) AT=650.05n

* CHECK dout0_31 Vdout0_31ck64 = 0 time = 650
.meas tran vdout0_31ck64 FIND v(dout0_31) AT=650.05n

* CHECK dout0_32 Vdout0_32ck64 = 0 time = 650
.meas tran vdout0_32ck64 FIND v(dout0_32) AT=650.05n

* CHECK dout0_0 Vdout0_0ck65 = 1.8 time = 660
.meas tran vdout0_0ck65 FIND v(dout0_0) AT=660.05n

* CHECK dout0_1 Vdout0_1ck65 = 1.8 time = 660
.meas tran vdout0_1ck65 FIND v(dout0_1) AT=660.05n

* CHECK dout0_2 Vdout0_2ck65 = 0 time = 660
.meas tran vdout0_2ck65 FIND v(dout0_2) AT=660.05n

* CHECK dout0_3 Vdout0_3ck65 = 1.8 time = 660
.meas tran vdout0_3ck65 FIND v(dout0_3) AT=660.05n

* CHECK dout0_4 Vdout0_4ck65 = 0 time = 660
.meas tran vdout0_4ck65 FIND v(dout0_4) AT=660.05n

* CHECK dout0_5 Vdout0_5ck65 = 0 time = 660
.meas tran vdout0_5ck65 FIND v(dout0_5) AT=660.05n

* CHECK dout0_6 Vdout0_6ck65 = 1.8 time = 660
.meas tran vdout0_6ck65 FIND v(dout0_6) AT=660.05n

* CHECK dout0_7 Vdout0_7ck65 = 0 time = 660
.meas tran vdout0_7ck65 FIND v(dout0_7) AT=660.05n

* CHECK dout0_8 Vdout0_8ck65 = 0 time = 660
.meas tran vdout0_8ck65 FIND v(dout0_8) AT=660.05n

* CHECK dout0_9 Vdout0_9ck65 = 1.8 time = 660
.meas tran vdout0_9ck65 FIND v(dout0_9) AT=660.05n

* CHECK dout0_10 Vdout0_10ck65 = 1.8 time = 660
.meas tran vdout0_10ck65 FIND v(dout0_10) AT=660.05n

* CHECK dout0_11 Vdout0_11ck65 = 1.8 time = 660
.meas tran vdout0_11ck65 FIND v(dout0_11) AT=660.05n

* CHECK dout0_12 Vdout0_12ck65 = 1.8 time = 660
.meas tran vdout0_12ck65 FIND v(dout0_12) AT=660.05n

* CHECK dout0_13 Vdout0_13ck65 = 0 time = 660
.meas tran vdout0_13ck65 FIND v(dout0_13) AT=660.05n

* CHECK dout0_14 Vdout0_14ck65 = 1.8 time = 660
.meas tran vdout0_14ck65 FIND v(dout0_14) AT=660.05n

* CHECK dout0_15 Vdout0_15ck65 = 1.8 time = 660
.meas tran vdout0_15ck65 FIND v(dout0_15) AT=660.05n

* CHECK dout0_16 Vdout0_16ck65 = 0 time = 660
.meas tran vdout0_16ck65 FIND v(dout0_16) AT=660.05n

* CHECK dout0_17 Vdout0_17ck65 = 1.8 time = 660
.meas tran vdout0_17ck65 FIND v(dout0_17) AT=660.05n

* CHECK dout0_18 Vdout0_18ck65 = 0 time = 660
.meas tran vdout0_18ck65 FIND v(dout0_18) AT=660.05n

* CHECK dout0_19 Vdout0_19ck65 = 1.8 time = 660
.meas tran vdout0_19ck65 FIND v(dout0_19) AT=660.05n

* CHECK dout0_20 Vdout0_20ck65 = 1.8 time = 660
.meas tran vdout0_20ck65 FIND v(dout0_20) AT=660.05n

* CHECK dout0_21 Vdout0_21ck65 = 1.8 time = 660
.meas tran vdout0_21ck65 FIND v(dout0_21) AT=660.05n

* CHECK dout0_22 Vdout0_22ck65 = 1.8 time = 660
.meas tran vdout0_22ck65 FIND v(dout0_22) AT=660.05n

* CHECK dout0_23 Vdout0_23ck65 = 0 time = 660
.meas tran vdout0_23ck65 FIND v(dout0_23) AT=660.05n

* CHECK dout0_24 Vdout0_24ck65 = 0 time = 660
.meas tran vdout0_24ck65 FIND v(dout0_24) AT=660.05n

* CHECK dout0_25 Vdout0_25ck65 = 1.8 time = 660
.meas tran vdout0_25ck65 FIND v(dout0_25) AT=660.05n

* CHECK dout0_26 Vdout0_26ck65 = 0 time = 660
.meas tran vdout0_26ck65 FIND v(dout0_26) AT=660.05n

* CHECK dout0_27 Vdout0_27ck65 = 1.8 time = 660
.meas tran vdout0_27ck65 FIND v(dout0_27) AT=660.05n

* CHECK dout0_28 Vdout0_28ck65 = 1.8 time = 660
.meas tran vdout0_28ck65 FIND v(dout0_28) AT=660.05n

* CHECK dout0_29 Vdout0_29ck65 = 0 time = 660
.meas tran vdout0_29ck65 FIND v(dout0_29) AT=660.05n

* CHECK dout0_30 Vdout0_30ck65 = 1.8 time = 660
.meas tran vdout0_30ck65 FIND v(dout0_30) AT=660.05n

* CHECK dout0_31 Vdout0_31ck65 = 1.8 time = 660
.meas tran vdout0_31ck65 FIND v(dout0_31) AT=660.05n

* CHECK dout0_32 Vdout0_32ck65 = 0 time = 660
.meas tran vdout0_32ck65 FIND v(dout0_32) AT=660.05n

* CHECK dout0_0 Vdout0_0ck67 = 1.8 time = 680
.meas tran vdout0_0ck67 FIND v(dout0_0) AT=680.05n

* CHECK dout0_1 Vdout0_1ck67 = 1.8 time = 680
.meas tran vdout0_1ck67 FIND v(dout0_1) AT=680.05n

* CHECK dout0_2 Vdout0_2ck67 = 0 time = 680
.meas tran vdout0_2ck67 FIND v(dout0_2) AT=680.05n

* CHECK dout0_3 Vdout0_3ck67 = 1.8 time = 680
.meas tran vdout0_3ck67 FIND v(dout0_3) AT=680.05n

* CHECK dout0_4 Vdout0_4ck67 = 0 time = 680
.meas tran vdout0_4ck67 FIND v(dout0_4) AT=680.05n

* CHECK dout0_5 Vdout0_5ck67 = 0 time = 680
.meas tran vdout0_5ck67 FIND v(dout0_5) AT=680.05n

* CHECK dout0_6 Vdout0_6ck67 = 1.8 time = 680
.meas tran vdout0_6ck67 FIND v(dout0_6) AT=680.05n

* CHECK dout0_7 Vdout0_7ck67 = 0 time = 680
.meas tran vdout0_7ck67 FIND v(dout0_7) AT=680.05n

* CHECK dout0_8 Vdout0_8ck67 = 0 time = 680
.meas tran vdout0_8ck67 FIND v(dout0_8) AT=680.05n

* CHECK dout0_9 Vdout0_9ck67 = 1.8 time = 680
.meas tran vdout0_9ck67 FIND v(dout0_9) AT=680.05n

* CHECK dout0_10 Vdout0_10ck67 = 1.8 time = 680
.meas tran vdout0_10ck67 FIND v(dout0_10) AT=680.05n

* CHECK dout0_11 Vdout0_11ck67 = 1.8 time = 680
.meas tran vdout0_11ck67 FIND v(dout0_11) AT=680.05n

* CHECK dout0_12 Vdout0_12ck67 = 1.8 time = 680
.meas tran vdout0_12ck67 FIND v(dout0_12) AT=680.05n

* CHECK dout0_13 Vdout0_13ck67 = 0 time = 680
.meas tran vdout0_13ck67 FIND v(dout0_13) AT=680.05n

* CHECK dout0_14 Vdout0_14ck67 = 1.8 time = 680
.meas tran vdout0_14ck67 FIND v(dout0_14) AT=680.05n

* CHECK dout0_15 Vdout0_15ck67 = 1.8 time = 680
.meas tran vdout0_15ck67 FIND v(dout0_15) AT=680.05n

* CHECK dout0_16 Vdout0_16ck67 = 0 time = 680
.meas tran vdout0_16ck67 FIND v(dout0_16) AT=680.05n

* CHECK dout0_17 Vdout0_17ck67 = 1.8 time = 680
.meas tran vdout0_17ck67 FIND v(dout0_17) AT=680.05n

* CHECK dout0_18 Vdout0_18ck67 = 0 time = 680
.meas tran vdout0_18ck67 FIND v(dout0_18) AT=680.05n

* CHECK dout0_19 Vdout0_19ck67 = 1.8 time = 680
.meas tran vdout0_19ck67 FIND v(dout0_19) AT=680.05n

* CHECK dout0_20 Vdout0_20ck67 = 1.8 time = 680
.meas tran vdout0_20ck67 FIND v(dout0_20) AT=680.05n

* CHECK dout0_21 Vdout0_21ck67 = 1.8 time = 680
.meas tran vdout0_21ck67 FIND v(dout0_21) AT=680.05n

* CHECK dout0_22 Vdout0_22ck67 = 1.8 time = 680
.meas tran vdout0_22ck67 FIND v(dout0_22) AT=680.05n

* CHECK dout0_23 Vdout0_23ck67 = 0 time = 680
.meas tran vdout0_23ck67 FIND v(dout0_23) AT=680.05n

* CHECK dout0_24 Vdout0_24ck67 = 0 time = 680
.meas tran vdout0_24ck67 FIND v(dout0_24) AT=680.05n

* CHECK dout0_25 Vdout0_25ck67 = 1.8 time = 680
.meas tran vdout0_25ck67 FIND v(dout0_25) AT=680.05n

* CHECK dout0_26 Vdout0_26ck67 = 0 time = 680
.meas tran vdout0_26ck67 FIND v(dout0_26) AT=680.05n

* CHECK dout0_27 Vdout0_27ck67 = 1.8 time = 680
.meas tran vdout0_27ck67 FIND v(dout0_27) AT=680.05n

* CHECK dout0_28 Vdout0_28ck67 = 1.8 time = 680
.meas tran vdout0_28ck67 FIND v(dout0_28) AT=680.05n

* CHECK dout0_29 Vdout0_29ck67 = 0 time = 680
.meas tran vdout0_29ck67 FIND v(dout0_29) AT=680.05n

* CHECK dout0_30 Vdout0_30ck67 = 1.8 time = 680
.meas tran vdout0_30ck67 FIND v(dout0_30) AT=680.05n

* CHECK dout0_31 Vdout0_31ck67 = 1.8 time = 680
.meas tran vdout0_31ck67 FIND v(dout0_31) AT=680.05n

* CHECK dout0_32 Vdout0_32ck67 = 0 time = 680
.meas tran vdout0_32ck67 FIND v(dout0_32) AT=680.05n

* CHECK dout0_0 Vdout0_0ck68 = 1.8 time = 690
.meas tran vdout0_0ck68 FIND v(dout0_0) AT=690.05n

* CHECK dout0_1 Vdout0_1ck68 = 0 time = 690
.meas tran vdout0_1ck68 FIND v(dout0_1) AT=690.05n

* CHECK dout0_2 Vdout0_2ck68 = 1.8 time = 690
.meas tran vdout0_2ck68 FIND v(dout0_2) AT=690.05n

* CHECK dout0_3 Vdout0_3ck68 = 1.8 time = 690
.meas tran vdout0_3ck68 FIND v(dout0_3) AT=690.05n

* CHECK dout0_4 Vdout0_4ck68 = 1.8 time = 690
.meas tran vdout0_4ck68 FIND v(dout0_4) AT=690.05n

* CHECK dout0_5 Vdout0_5ck68 = 1.8 time = 690
.meas tran vdout0_5ck68 FIND v(dout0_5) AT=690.05n

* CHECK dout0_6 Vdout0_6ck68 = 0 time = 690
.meas tran vdout0_6ck68 FIND v(dout0_6) AT=690.05n

* CHECK dout0_7 Vdout0_7ck68 = 1.8 time = 690
.meas tran vdout0_7ck68 FIND v(dout0_7) AT=690.05n

* CHECK dout0_8 Vdout0_8ck68 = 0 time = 690
.meas tran vdout0_8ck68 FIND v(dout0_8) AT=690.05n

* CHECK dout0_9 Vdout0_9ck68 = 1.8 time = 690
.meas tran vdout0_9ck68 FIND v(dout0_9) AT=690.05n

* CHECK dout0_10 Vdout0_10ck68 = 0 time = 690
.meas tran vdout0_10ck68 FIND v(dout0_10) AT=690.05n

* CHECK dout0_11 Vdout0_11ck68 = 1.8 time = 690
.meas tran vdout0_11ck68 FIND v(dout0_11) AT=690.05n

* CHECK dout0_12 Vdout0_12ck68 = 0 time = 690
.meas tran vdout0_12ck68 FIND v(dout0_12) AT=690.05n

* CHECK dout0_13 Vdout0_13ck68 = 0 time = 690
.meas tran vdout0_13ck68 FIND v(dout0_13) AT=690.05n

* CHECK dout0_14 Vdout0_14ck68 = 0 time = 690
.meas tran vdout0_14ck68 FIND v(dout0_14) AT=690.05n

* CHECK dout0_15 Vdout0_15ck68 = 0 time = 690
.meas tran vdout0_15ck68 FIND v(dout0_15) AT=690.05n

* CHECK dout0_16 Vdout0_16ck68 = 1.8 time = 690
.meas tran vdout0_16ck68 FIND v(dout0_16) AT=690.05n

* CHECK dout0_17 Vdout0_17ck68 = 1.8 time = 690
.meas tran vdout0_17ck68 FIND v(dout0_17) AT=690.05n

* CHECK dout0_18 Vdout0_18ck68 = 1.8 time = 690
.meas tran vdout0_18ck68 FIND v(dout0_18) AT=690.05n

* CHECK dout0_19 Vdout0_19ck68 = 0 time = 690
.meas tran vdout0_19ck68 FIND v(dout0_19) AT=690.05n

* CHECK dout0_20 Vdout0_20ck68 = 0 time = 690
.meas tran vdout0_20ck68 FIND v(dout0_20) AT=690.05n

* CHECK dout0_21 Vdout0_21ck68 = 1.8 time = 690
.meas tran vdout0_21ck68 FIND v(dout0_21) AT=690.05n

* CHECK dout0_22 Vdout0_22ck68 = 1.8 time = 690
.meas tran vdout0_22ck68 FIND v(dout0_22) AT=690.05n

* CHECK dout0_23 Vdout0_23ck68 = 1.8 time = 690
.meas tran vdout0_23ck68 FIND v(dout0_23) AT=690.05n

* CHECK dout0_24 Vdout0_24ck68 = 0 time = 690
.meas tran vdout0_24ck68 FIND v(dout0_24) AT=690.05n

* CHECK dout0_25 Vdout0_25ck68 = 1.8 time = 690
.meas tran vdout0_25ck68 FIND v(dout0_25) AT=690.05n

* CHECK dout0_26 Vdout0_26ck68 = 0 time = 690
.meas tran vdout0_26ck68 FIND v(dout0_26) AT=690.05n

* CHECK dout0_27 Vdout0_27ck68 = 0 time = 690
.meas tran vdout0_27ck68 FIND v(dout0_27) AT=690.05n

* CHECK dout0_28 Vdout0_28ck68 = 1.8 time = 690
.meas tran vdout0_28ck68 FIND v(dout0_28) AT=690.05n

* CHECK dout0_29 Vdout0_29ck68 = 1.8 time = 690
.meas tran vdout0_29ck68 FIND v(dout0_29) AT=690.05n

* CHECK dout0_30 Vdout0_30ck68 = 0 time = 690
.meas tran vdout0_30ck68 FIND v(dout0_30) AT=690.05n

* CHECK dout0_31 Vdout0_31ck68 = 0 time = 690
.meas tran vdout0_31ck68 FIND v(dout0_31) AT=690.05n

* CHECK dout0_32 Vdout0_32ck68 = 0 time = 690
.meas tran vdout0_32ck68 FIND v(dout0_32) AT=690.05n

* CHECK dout0_0 Vdout0_0ck71 = 1.8 time = 720
.meas tran vdout0_0ck71 FIND v(dout0_0) AT=720.05n

* CHECK dout0_1 Vdout0_1ck71 = 1.8 time = 720
.meas tran vdout0_1ck71 FIND v(dout0_1) AT=720.05n

* CHECK dout0_2 Vdout0_2ck71 = 1.8 time = 720
.meas tran vdout0_2ck71 FIND v(dout0_2) AT=720.05n

* CHECK dout0_3 Vdout0_3ck71 = 0 time = 720
.meas tran vdout0_3ck71 FIND v(dout0_3) AT=720.05n

* CHECK dout0_4 Vdout0_4ck71 = 0 time = 720
.meas tran vdout0_4ck71 FIND v(dout0_4) AT=720.05n

* CHECK dout0_5 Vdout0_5ck71 = 0 time = 720
.meas tran vdout0_5ck71 FIND v(dout0_5) AT=720.05n

* CHECK dout0_6 Vdout0_6ck71 = 0 time = 720
.meas tran vdout0_6ck71 FIND v(dout0_6) AT=720.05n

* CHECK dout0_7 Vdout0_7ck71 = 1.8 time = 720
.meas tran vdout0_7ck71 FIND v(dout0_7) AT=720.05n

* CHECK dout0_8 Vdout0_8ck71 = 0 time = 720
.meas tran vdout0_8ck71 FIND v(dout0_8) AT=720.05n

* CHECK dout0_9 Vdout0_9ck71 = 1.8 time = 720
.meas tran vdout0_9ck71 FIND v(dout0_9) AT=720.05n

* CHECK dout0_10 Vdout0_10ck71 = 1.8 time = 720
.meas tran vdout0_10ck71 FIND v(dout0_10) AT=720.05n

* CHECK dout0_11 Vdout0_11ck71 = 1.8 time = 720
.meas tran vdout0_11ck71 FIND v(dout0_11) AT=720.05n

* CHECK dout0_12 Vdout0_12ck71 = 0 time = 720
.meas tran vdout0_12ck71 FIND v(dout0_12) AT=720.05n

* CHECK dout0_13 Vdout0_13ck71 = 0 time = 720
.meas tran vdout0_13ck71 FIND v(dout0_13) AT=720.05n

* CHECK dout0_14 Vdout0_14ck71 = 0 time = 720
.meas tran vdout0_14ck71 FIND v(dout0_14) AT=720.05n

* CHECK dout0_15 Vdout0_15ck71 = 0 time = 720
.meas tran vdout0_15ck71 FIND v(dout0_15) AT=720.05n

* CHECK dout0_16 Vdout0_16ck71 = 1.8 time = 720
.meas tran vdout0_16ck71 FIND v(dout0_16) AT=720.05n

* CHECK dout0_17 Vdout0_17ck71 = 1.8 time = 720
.meas tran vdout0_17ck71 FIND v(dout0_17) AT=720.05n

* CHECK dout0_18 Vdout0_18ck71 = 1.8 time = 720
.meas tran vdout0_18ck71 FIND v(dout0_18) AT=720.05n

* CHECK dout0_19 Vdout0_19ck71 = 1.8 time = 720
.meas tran vdout0_19ck71 FIND v(dout0_19) AT=720.05n

* CHECK dout0_20 Vdout0_20ck71 = 0 time = 720
.meas tran vdout0_20ck71 FIND v(dout0_20) AT=720.05n

* CHECK dout0_21 Vdout0_21ck71 = 0 time = 720
.meas tran vdout0_21ck71 FIND v(dout0_21) AT=720.05n

* CHECK dout0_22 Vdout0_22ck71 = 1.8 time = 720
.meas tran vdout0_22ck71 FIND v(dout0_22) AT=720.05n

* CHECK dout0_23 Vdout0_23ck71 = 1.8 time = 720
.meas tran vdout0_23ck71 FIND v(dout0_23) AT=720.05n

* CHECK dout0_24 Vdout0_24ck71 = 1.8 time = 720
.meas tran vdout0_24ck71 FIND v(dout0_24) AT=720.05n

* CHECK dout0_25 Vdout0_25ck71 = 0 time = 720
.meas tran vdout0_25ck71 FIND v(dout0_25) AT=720.05n

* CHECK dout0_26 Vdout0_26ck71 = 0 time = 720
.meas tran vdout0_26ck71 FIND v(dout0_26) AT=720.05n

* CHECK dout0_27 Vdout0_27ck71 = 0 time = 720
.meas tran vdout0_27ck71 FIND v(dout0_27) AT=720.05n

* CHECK dout0_28 Vdout0_28ck71 = 1.8 time = 720
.meas tran vdout0_28ck71 FIND v(dout0_28) AT=720.05n

* CHECK dout0_29 Vdout0_29ck71 = 0 time = 720
.meas tran vdout0_29ck71 FIND v(dout0_29) AT=720.05n

* CHECK dout0_30 Vdout0_30ck71 = 0 time = 720
.meas tran vdout0_30ck71 FIND v(dout0_30) AT=720.05n

* CHECK dout0_31 Vdout0_31ck71 = 1.8 time = 720
.meas tran vdout0_31ck71 FIND v(dout0_31) AT=720.05n

* CHECK dout0_32 Vdout0_32ck71 = 0 time = 720
.meas tran vdout0_32ck71 FIND v(dout0_32) AT=720.05n

* CHECK dout0_0 Vdout0_0ck76 = 1.8 time = 770
.meas tran vdout0_0ck76 FIND v(dout0_0) AT=770.05n

* CHECK dout0_1 Vdout0_1ck76 = 1.8 time = 770
.meas tran vdout0_1ck76 FIND v(dout0_1) AT=770.05n

* CHECK dout0_2 Vdout0_2ck76 = 0 time = 770
.meas tran vdout0_2ck76 FIND v(dout0_2) AT=770.05n

* CHECK dout0_3 Vdout0_3ck76 = 1.8 time = 770
.meas tran vdout0_3ck76 FIND v(dout0_3) AT=770.05n

* CHECK dout0_4 Vdout0_4ck76 = 0 time = 770
.meas tran vdout0_4ck76 FIND v(dout0_4) AT=770.05n

* CHECK dout0_5 Vdout0_5ck76 = 1.8 time = 770
.meas tran vdout0_5ck76 FIND v(dout0_5) AT=770.05n

* CHECK dout0_6 Vdout0_6ck76 = 0 time = 770
.meas tran vdout0_6ck76 FIND v(dout0_6) AT=770.05n

* CHECK dout0_7 Vdout0_7ck76 = 0 time = 770
.meas tran vdout0_7ck76 FIND v(dout0_7) AT=770.05n

* CHECK dout0_8 Vdout0_8ck76 = 0 time = 770
.meas tran vdout0_8ck76 FIND v(dout0_8) AT=770.05n

* CHECK dout0_9 Vdout0_9ck76 = 1.8 time = 770
.meas tran vdout0_9ck76 FIND v(dout0_9) AT=770.05n

* CHECK dout0_10 Vdout0_10ck76 = 0 time = 770
.meas tran vdout0_10ck76 FIND v(dout0_10) AT=770.05n

* CHECK dout0_11 Vdout0_11ck76 = 1.8 time = 770
.meas tran vdout0_11ck76 FIND v(dout0_11) AT=770.05n

* CHECK dout0_12 Vdout0_12ck76 = 1.8 time = 770
.meas tran vdout0_12ck76 FIND v(dout0_12) AT=770.05n

* CHECK dout0_13 Vdout0_13ck76 = 1.8 time = 770
.meas tran vdout0_13ck76 FIND v(dout0_13) AT=770.05n

* CHECK dout0_14 Vdout0_14ck76 = 1.8 time = 770
.meas tran vdout0_14ck76 FIND v(dout0_14) AT=770.05n

* CHECK dout0_15 Vdout0_15ck76 = 0 time = 770
.meas tran vdout0_15ck76 FIND v(dout0_15) AT=770.05n

* CHECK dout0_16 Vdout0_16ck76 = 0 time = 770
.meas tran vdout0_16ck76 FIND v(dout0_16) AT=770.05n

* CHECK dout0_17 Vdout0_17ck76 = 1.8 time = 770
.meas tran vdout0_17ck76 FIND v(dout0_17) AT=770.05n

* CHECK dout0_18 Vdout0_18ck76 = 1.8 time = 770
.meas tran vdout0_18ck76 FIND v(dout0_18) AT=770.05n

* CHECK dout0_19 Vdout0_19ck76 = 1.8 time = 770
.meas tran vdout0_19ck76 FIND v(dout0_19) AT=770.05n

* CHECK dout0_20 Vdout0_20ck76 = 0 time = 770
.meas tran vdout0_20ck76 FIND v(dout0_20) AT=770.05n

* CHECK dout0_21 Vdout0_21ck76 = 1.8 time = 770
.meas tran vdout0_21ck76 FIND v(dout0_21) AT=770.05n

* CHECK dout0_22 Vdout0_22ck76 = 1.8 time = 770
.meas tran vdout0_22ck76 FIND v(dout0_22) AT=770.05n

* CHECK dout0_23 Vdout0_23ck76 = 1.8 time = 770
.meas tran vdout0_23ck76 FIND v(dout0_23) AT=770.05n

* CHECK dout0_24 Vdout0_24ck76 = 1.8 time = 770
.meas tran vdout0_24ck76 FIND v(dout0_24) AT=770.05n

* CHECK dout0_25 Vdout0_25ck76 = 0 time = 770
.meas tran vdout0_25ck76 FIND v(dout0_25) AT=770.05n

* CHECK dout0_26 Vdout0_26ck76 = 1.8 time = 770
.meas tran vdout0_26ck76 FIND v(dout0_26) AT=770.05n

* CHECK dout0_27 Vdout0_27ck76 = 1.8 time = 770
.meas tran vdout0_27ck76 FIND v(dout0_27) AT=770.05n

* CHECK dout0_28 Vdout0_28ck76 = 1.8 time = 770
.meas tran vdout0_28ck76 FIND v(dout0_28) AT=770.05n

* CHECK dout0_29 Vdout0_29ck76 = 1.8 time = 770
.meas tran vdout0_29ck76 FIND v(dout0_29) AT=770.05n

* CHECK dout0_30 Vdout0_30ck76 = 0 time = 770
.meas tran vdout0_30ck76 FIND v(dout0_30) AT=770.05n

* CHECK dout0_31 Vdout0_31ck76 = 0 time = 770
.meas tran vdout0_31ck76 FIND v(dout0_31) AT=770.05n

* CHECK dout0_32 Vdout0_32ck76 = 0 time = 770
.meas tran vdout0_32ck76 FIND v(dout0_32) AT=770.05n

* CHECK dout0_0 Vdout0_0ck82 = 0 time = 830
.meas tran vdout0_0ck82 FIND v(dout0_0) AT=830.05n

* CHECK dout0_1 Vdout0_1ck82 = 1.8 time = 830
.meas tran vdout0_1ck82 FIND v(dout0_1) AT=830.05n

* CHECK dout0_2 Vdout0_2ck82 = 1.8 time = 830
.meas tran vdout0_2ck82 FIND v(dout0_2) AT=830.05n

* CHECK dout0_3 Vdout0_3ck82 = 1.8 time = 830
.meas tran vdout0_3ck82 FIND v(dout0_3) AT=830.05n

* CHECK dout0_4 Vdout0_4ck82 = 0 time = 830
.meas tran vdout0_4ck82 FIND v(dout0_4) AT=830.05n

* CHECK dout0_5 Vdout0_5ck82 = 1.8 time = 830
.meas tran vdout0_5ck82 FIND v(dout0_5) AT=830.05n

* CHECK dout0_6 Vdout0_6ck82 = 0 time = 830
.meas tran vdout0_6ck82 FIND v(dout0_6) AT=830.05n

* CHECK dout0_7 Vdout0_7ck82 = 0 time = 830
.meas tran vdout0_7ck82 FIND v(dout0_7) AT=830.05n

* CHECK dout0_8 Vdout0_8ck82 = 0 time = 830
.meas tran vdout0_8ck82 FIND v(dout0_8) AT=830.05n

* CHECK dout0_9 Vdout0_9ck82 = 0 time = 830
.meas tran vdout0_9ck82 FIND v(dout0_9) AT=830.05n

* CHECK dout0_10 Vdout0_10ck82 = 0 time = 830
.meas tran vdout0_10ck82 FIND v(dout0_10) AT=830.05n

* CHECK dout0_11 Vdout0_11ck82 = 1.8 time = 830
.meas tran vdout0_11ck82 FIND v(dout0_11) AT=830.05n

* CHECK dout0_12 Vdout0_12ck82 = 1.8 time = 830
.meas tran vdout0_12ck82 FIND v(dout0_12) AT=830.05n

* CHECK dout0_13 Vdout0_13ck82 = 1.8 time = 830
.meas tran vdout0_13ck82 FIND v(dout0_13) AT=830.05n

* CHECK dout0_14 Vdout0_14ck82 = 0 time = 830
.meas tran vdout0_14ck82 FIND v(dout0_14) AT=830.05n

* CHECK dout0_15 Vdout0_15ck82 = 1.8 time = 830
.meas tran vdout0_15ck82 FIND v(dout0_15) AT=830.05n

* CHECK dout0_16 Vdout0_16ck82 = 0 time = 830
.meas tran vdout0_16ck82 FIND v(dout0_16) AT=830.05n

* CHECK dout0_17 Vdout0_17ck82 = 0 time = 830
.meas tran vdout0_17ck82 FIND v(dout0_17) AT=830.05n

* CHECK dout0_18 Vdout0_18ck82 = 0 time = 830
.meas tran vdout0_18ck82 FIND v(dout0_18) AT=830.05n

* CHECK dout0_19 Vdout0_19ck82 = 1.8 time = 830
.meas tran vdout0_19ck82 FIND v(dout0_19) AT=830.05n

* CHECK dout0_20 Vdout0_20ck82 = 1.8 time = 830
.meas tran vdout0_20ck82 FIND v(dout0_20) AT=830.05n

* CHECK dout0_21 Vdout0_21ck82 = 0 time = 830
.meas tran vdout0_21ck82 FIND v(dout0_21) AT=830.05n

* CHECK dout0_22 Vdout0_22ck82 = 0 time = 830
.meas tran vdout0_22ck82 FIND v(dout0_22) AT=830.05n

* CHECK dout0_23 Vdout0_23ck82 = 1.8 time = 830
.meas tran vdout0_23ck82 FIND v(dout0_23) AT=830.05n

* CHECK dout0_24 Vdout0_24ck82 = 0 time = 830
.meas tran vdout0_24ck82 FIND v(dout0_24) AT=830.05n

* CHECK dout0_25 Vdout0_25ck82 = 0 time = 830
.meas tran vdout0_25ck82 FIND v(dout0_25) AT=830.05n

* CHECK dout0_26 Vdout0_26ck82 = 0 time = 830
.meas tran vdout0_26ck82 FIND v(dout0_26) AT=830.05n

* CHECK dout0_27 Vdout0_27ck82 = 0 time = 830
.meas tran vdout0_27ck82 FIND v(dout0_27) AT=830.05n

* CHECK dout0_28 Vdout0_28ck82 = 0 time = 830
.meas tran vdout0_28ck82 FIND v(dout0_28) AT=830.05n

* CHECK dout0_29 Vdout0_29ck82 = 0 time = 830
.meas tran vdout0_29ck82 FIND v(dout0_29) AT=830.05n

* CHECK dout0_30 Vdout0_30ck82 = 0 time = 830
.meas tran vdout0_30ck82 FIND v(dout0_30) AT=830.05n

* CHECK dout0_31 Vdout0_31ck82 = 0 time = 830
.meas tran vdout0_31ck82 FIND v(dout0_31) AT=830.05n

* CHECK dout0_32 Vdout0_32ck82 = 0 time = 830
.meas tran vdout0_32ck82 FIND v(dout0_32) AT=830.05n

* CHECK dout0_0 Vdout0_0ck83 = 1.8 time = 840
.meas tran vdout0_0ck83 FIND v(dout0_0) AT=840.05n

* CHECK dout0_1 Vdout0_1ck83 = 0 time = 840
.meas tran vdout0_1ck83 FIND v(dout0_1) AT=840.05n

* CHECK dout0_2 Vdout0_2ck83 = 0 time = 840
.meas tran vdout0_2ck83 FIND v(dout0_2) AT=840.05n

* CHECK dout0_3 Vdout0_3ck83 = 1.8 time = 840
.meas tran vdout0_3ck83 FIND v(dout0_3) AT=840.05n

* CHECK dout0_4 Vdout0_4ck83 = 1.8 time = 840
.meas tran vdout0_4ck83 FIND v(dout0_4) AT=840.05n

* CHECK dout0_5 Vdout0_5ck83 = 1.8 time = 840
.meas tran vdout0_5ck83 FIND v(dout0_5) AT=840.05n

* CHECK dout0_6 Vdout0_6ck83 = 0 time = 840
.meas tran vdout0_6ck83 FIND v(dout0_6) AT=840.05n

* CHECK dout0_7 Vdout0_7ck83 = 0 time = 840
.meas tran vdout0_7ck83 FIND v(dout0_7) AT=840.05n

* CHECK dout0_8 Vdout0_8ck83 = 1.8 time = 840
.meas tran vdout0_8ck83 FIND v(dout0_8) AT=840.05n

* CHECK dout0_9 Vdout0_9ck83 = 1.8 time = 840
.meas tran vdout0_9ck83 FIND v(dout0_9) AT=840.05n

* CHECK dout0_10 Vdout0_10ck83 = 1.8 time = 840
.meas tran vdout0_10ck83 FIND v(dout0_10) AT=840.05n

* CHECK dout0_11 Vdout0_11ck83 = 1.8 time = 840
.meas tran vdout0_11ck83 FIND v(dout0_11) AT=840.05n

* CHECK dout0_12 Vdout0_12ck83 = 0 time = 840
.meas tran vdout0_12ck83 FIND v(dout0_12) AT=840.05n

* CHECK dout0_13 Vdout0_13ck83 = 1.8 time = 840
.meas tran vdout0_13ck83 FIND v(dout0_13) AT=840.05n

* CHECK dout0_14 Vdout0_14ck83 = 1.8 time = 840
.meas tran vdout0_14ck83 FIND v(dout0_14) AT=840.05n

* CHECK dout0_15 Vdout0_15ck83 = 0 time = 840
.meas tran vdout0_15ck83 FIND v(dout0_15) AT=840.05n

* CHECK dout0_16 Vdout0_16ck83 = 0 time = 840
.meas tran vdout0_16ck83 FIND v(dout0_16) AT=840.05n

* CHECK dout0_17 Vdout0_17ck83 = 1.8 time = 840
.meas tran vdout0_17ck83 FIND v(dout0_17) AT=840.05n

* CHECK dout0_18 Vdout0_18ck83 = 0 time = 840
.meas tran vdout0_18ck83 FIND v(dout0_18) AT=840.05n

* CHECK dout0_19 Vdout0_19ck83 = 0 time = 840
.meas tran vdout0_19ck83 FIND v(dout0_19) AT=840.05n

* CHECK dout0_20 Vdout0_20ck83 = 1.8 time = 840
.meas tran vdout0_20ck83 FIND v(dout0_20) AT=840.05n

* CHECK dout0_21 Vdout0_21ck83 = 0 time = 840
.meas tran vdout0_21ck83 FIND v(dout0_21) AT=840.05n

* CHECK dout0_22 Vdout0_22ck83 = 0 time = 840
.meas tran vdout0_22ck83 FIND v(dout0_22) AT=840.05n

* CHECK dout0_23 Vdout0_23ck83 = 0 time = 840
.meas tran vdout0_23ck83 FIND v(dout0_23) AT=840.05n

* CHECK dout0_24 Vdout0_24ck83 = 1.8 time = 840
.meas tran vdout0_24ck83 FIND v(dout0_24) AT=840.05n

* CHECK dout0_25 Vdout0_25ck83 = 0 time = 840
.meas tran vdout0_25ck83 FIND v(dout0_25) AT=840.05n

* CHECK dout0_26 Vdout0_26ck83 = 1.8 time = 840
.meas tran vdout0_26ck83 FIND v(dout0_26) AT=840.05n

* CHECK dout0_27 Vdout0_27ck83 = 1.8 time = 840
.meas tran vdout0_27ck83 FIND v(dout0_27) AT=840.05n

* CHECK dout0_28 Vdout0_28ck83 = 0 time = 840
.meas tran vdout0_28ck83 FIND v(dout0_28) AT=840.05n

* CHECK dout0_29 Vdout0_29ck83 = 1.8 time = 840
.meas tran vdout0_29ck83 FIND v(dout0_29) AT=840.05n

* CHECK dout0_30 Vdout0_30ck83 = 0 time = 840
.meas tran vdout0_30ck83 FIND v(dout0_30) AT=840.05n

* CHECK dout0_31 Vdout0_31ck83 = 1.8 time = 840
.meas tran vdout0_31ck83 FIND v(dout0_31) AT=840.05n

* CHECK dout0_32 Vdout0_32ck83 = 0 time = 840
.meas tran vdout0_32ck83 FIND v(dout0_32) AT=840.05n

* CHECK dout0_0 Vdout0_0ck84 = 1.8 time = 850
.meas tran vdout0_0ck84 FIND v(dout0_0) AT=850.05n

* CHECK dout0_1 Vdout0_1ck84 = 0 time = 850
.meas tran vdout0_1ck84 FIND v(dout0_1) AT=850.05n

* CHECK dout0_2 Vdout0_2ck84 = 0 time = 850
.meas tran vdout0_2ck84 FIND v(dout0_2) AT=850.05n

* CHECK dout0_3 Vdout0_3ck84 = 1.8 time = 850
.meas tran vdout0_3ck84 FIND v(dout0_3) AT=850.05n

* CHECK dout0_4 Vdout0_4ck84 = 1.8 time = 850
.meas tran vdout0_4ck84 FIND v(dout0_4) AT=850.05n

* CHECK dout0_5 Vdout0_5ck84 = 1.8 time = 850
.meas tran vdout0_5ck84 FIND v(dout0_5) AT=850.05n

* CHECK dout0_6 Vdout0_6ck84 = 0 time = 850
.meas tran vdout0_6ck84 FIND v(dout0_6) AT=850.05n

* CHECK dout0_7 Vdout0_7ck84 = 0 time = 850
.meas tran vdout0_7ck84 FIND v(dout0_7) AT=850.05n

* CHECK dout0_8 Vdout0_8ck84 = 1.8 time = 850
.meas tran vdout0_8ck84 FIND v(dout0_8) AT=850.05n

* CHECK dout0_9 Vdout0_9ck84 = 1.8 time = 850
.meas tran vdout0_9ck84 FIND v(dout0_9) AT=850.05n

* CHECK dout0_10 Vdout0_10ck84 = 1.8 time = 850
.meas tran vdout0_10ck84 FIND v(dout0_10) AT=850.05n

* CHECK dout0_11 Vdout0_11ck84 = 1.8 time = 850
.meas tran vdout0_11ck84 FIND v(dout0_11) AT=850.05n

* CHECK dout0_12 Vdout0_12ck84 = 0 time = 850
.meas tran vdout0_12ck84 FIND v(dout0_12) AT=850.05n

* CHECK dout0_13 Vdout0_13ck84 = 1.8 time = 850
.meas tran vdout0_13ck84 FIND v(dout0_13) AT=850.05n

* CHECK dout0_14 Vdout0_14ck84 = 1.8 time = 850
.meas tran vdout0_14ck84 FIND v(dout0_14) AT=850.05n

* CHECK dout0_15 Vdout0_15ck84 = 0 time = 850
.meas tran vdout0_15ck84 FIND v(dout0_15) AT=850.05n

* CHECK dout0_16 Vdout0_16ck84 = 0 time = 850
.meas tran vdout0_16ck84 FIND v(dout0_16) AT=850.05n

* CHECK dout0_17 Vdout0_17ck84 = 1.8 time = 850
.meas tran vdout0_17ck84 FIND v(dout0_17) AT=850.05n

* CHECK dout0_18 Vdout0_18ck84 = 0 time = 850
.meas tran vdout0_18ck84 FIND v(dout0_18) AT=850.05n

* CHECK dout0_19 Vdout0_19ck84 = 0 time = 850
.meas tran vdout0_19ck84 FIND v(dout0_19) AT=850.05n

* CHECK dout0_20 Vdout0_20ck84 = 1.8 time = 850
.meas tran vdout0_20ck84 FIND v(dout0_20) AT=850.05n

* CHECK dout0_21 Vdout0_21ck84 = 0 time = 850
.meas tran vdout0_21ck84 FIND v(dout0_21) AT=850.05n

* CHECK dout0_22 Vdout0_22ck84 = 0 time = 850
.meas tran vdout0_22ck84 FIND v(dout0_22) AT=850.05n

* CHECK dout0_23 Vdout0_23ck84 = 0 time = 850
.meas tran vdout0_23ck84 FIND v(dout0_23) AT=850.05n

* CHECK dout0_24 Vdout0_24ck84 = 1.8 time = 850
.meas tran vdout0_24ck84 FIND v(dout0_24) AT=850.05n

* CHECK dout0_25 Vdout0_25ck84 = 0 time = 850
.meas tran vdout0_25ck84 FIND v(dout0_25) AT=850.05n

* CHECK dout0_26 Vdout0_26ck84 = 1.8 time = 850
.meas tran vdout0_26ck84 FIND v(dout0_26) AT=850.05n

* CHECK dout0_27 Vdout0_27ck84 = 1.8 time = 850
.meas tran vdout0_27ck84 FIND v(dout0_27) AT=850.05n

* CHECK dout0_28 Vdout0_28ck84 = 0 time = 850
.meas tran vdout0_28ck84 FIND v(dout0_28) AT=850.05n

* CHECK dout0_29 Vdout0_29ck84 = 1.8 time = 850
.meas tran vdout0_29ck84 FIND v(dout0_29) AT=850.05n

* CHECK dout0_30 Vdout0_30ck84 = 0 time = 850
.meas tran vdout0_30ck84 FIND v(dout0_30) AT=850.05n

* CHECK dout0_31 Vdout0_31ck84 = 1.8 time = 850
.meas tran vdout0_31ck84 FIND v(dout0_31) AT=850.05n

* CHECK dout0_32 Vdout0_32ck84 = 0 time = 850
.meas tran vdout0_32ck84 FIND v(dout0_32) AT=850.05n

* CHECK dout0_0 Vdout0_0ck87 = 1.8 time = 880
.meas tran vdout0_0ck87 FIND v(dout0_0) AT=880.05n

* CHECK dout0_1 Vdout0_1ck87 = 0 time = 880
.meas tran vdout0_1ck87 FIND v(dout0_1) AT=880.05n

* CHECK dout0_2 Vdout0_2ck87 = 0 time = 880
.meas tran vdout0_2ck87 FIND v(dout0_2) AT=880.05n

* CHECK dout0_3 Vdout0_3ck87 = 1.8 time = 880
.meas tran vdout0_3ck87 FIND v(dout0_3) AT=880.05n

* CHECK dout0_4 Vdout0_4ck87 = 1.8 time = 880
.meas tran vdout0_4ck87 FIND v(dout0_4) AT=880.05n

* CHECK dout0_5 Vdout0_5ck87 = 1.8 time = 880
.meas tran vdout0_5ck87 FIND v(dout0_5) AT=880.05n

* CHECK dout0_6 Vdout0_6ck87 = 0 time = 880
.meas tran vdout0_6ck87 FIND v(dout0_6) AT=880.05n

* CHECK dout0_7 Vdout0_7ck87 = 0 time = 880
.meas tran vdout0_7ck87 FIND v(dout0_7) AT=880.05n

* CHECK dout0_8 Vdout0_8ck87 = 1.8 time = 880
.meas tran vdout0_8ck87 FIND v(dout0_8) AT=880.05n

* CHECK dout0_9 Vdout0_9ck87 = 1.8 time = 880
.meas tran vdout0_9ck87 FIND v(dout0_9) AT=880.05n

* CHECK dout0_10 Vdout0_10ck87 = 1.8 time = 880
.meas tran vdout0_10ck87 FIND v(dout0_10) AT=880.05n

* CHECK dout0_11 Vdout0_11ck87 = 1.8 time = 880
.meas tran vdout0_11ck87 FIND v(dout0_11) AT=880.05n

* CHECK dout0_12 Vdout0_12ck87 = 0 time = 880
.meas tran vdout0_12ck87 FIND v(dout0_12) AT=880.05n

* CHECK dout0_13 Vdout0_13ck87 = 1.8 time = 880
.meas tran vdout0_13ck87 FIND v(dout0_13) AT=880.05n

* CHECK dout0_14 Vdout0_14ck87 = 1.8 time = 880
.meas tran vdout0_14ck87 FIND v(dout0_14) AT=880.05n

* CHECK dout0_15 Vdout0_15ck87 = 0 time = 880
.meas tran vdout0_15ck87 FIND v(dout0_15) AT=880.05n

* CHECK dout0_16 Vdout0_16ck87 = 0 time = 880
.meas tran vdout0_16ck87 FIND v(dout0_16) AT=880.05n

* CHECK dout0_17 Vdout0_17ck87 = 1.8 time = 880
.meas tran vdout0_17ck87 FIND v(dout0_17) AT=880.05n

* CHECK dout0_18 Vdout0_18ck87 = 0 time = 880
.meas tran vdout0_18ck87 FIND v(dout0_18) AT=880.05n

* CHECK dout0_19 Vdout0_19ck87 = 0 time = 880
.meas tran vdout0_19ck87 FIND v(dout0_19) AT=880.05n

* CHECK dout0_20 Vdout0_20ck87 = 1.8 time = 880
.meas tran vdout0_20ck87 FIND v(dout0_20) AT=880.05n

* CHECK dout0_21 Vdout0_21ck87 = 0 time = 880
.meas tran vdout0_21ck87 FIND v(dout0_21) AT=880.05n

* CHECK dout0_22 Vdout0_22ck87 = 0 time = 880
.meas tran vdout0_22ck87 FIND v(dout0_22) AT=880.05n

* CHECK dout0_23 Vdout0_23ck87 = 0 time = 880
.meas tran vdout0_23ck87 FIND v(dout0_23) AT=880.05n

* CHECK dout0_24 Vdout0_24ck87 = 1.8 time = 880
.meas tran vdout0_24ck87 FIND v(dout0_24) AT=880.05n

* CHECK dout0_25 Vdout0_25ck87 = 0 time = 880
.meas tran vdout0_25ck87 FIND v(dout0_25) AT=880.05n

* CHECK dout0_26 Vdout0_26ck87 = 1.8 time = 880
.meas tran vdout0_26ck87 FIND v(dout0_26) AT=880.05n

* CHECK dout0_27 Vdout0_27ck87 = 1.8 time = 880
.meas tran vdout0_27ck87 FIND v(dout0_27) AT=880.05n

* CHECK dout0_28 Vdout0_28ck87 = 0 time = 880
.meas tran vdout0_28ck87 FIND v(dout0_28) AT=880.05n

* CHECK dout0_29 Vdout0_29ck87 = 1.8 time = 880
.meas tran vdout0_29ck87 FIND v(dout0_29) AT=880.05n

* CHECK dout0_30 Vdout0_30ck87 = 0 time = 880
.meas tran vdout0_30ck87 FIND v(dout0_30) AT=880.05n

* CHECK dout0_31 Vdout0_31ck87 = 1.8 time = 880
.meas tran vdout0_31ck87 FIND v(dout0_31) AT=880.05n

* CHECK dout0_32 Vdout0_32ck87 = 0 time = 880
.meas tran vdout0_32ck87 FIND v(dout0_32) AT=880.05n

* CHECK dout0_0 Vdout0_0ck88 = 1.8 time = 890
.meas tran vdout0_0ck88 FIND v(dout0_0) AT=890.05n

* CHECK dout0_1 Vdout0_1ck88 = 0 time = 890
.meas tran vdout0_1ck88 FIND v(dout0_1) AT=890.05n

* CHECK dout0_2 Vdout0_2ck88 = 0 time = 890
.meas tran vdout0_2ck88 FIND v(dout0_2) AT=890.05n

* CHECK dout0_3 Vdout0_3ck88 = 1.8 time = 890
.meas tran vdout0_3ck88 FIND v(dout0_3) AT=890.05n

* CHECK dout0_4 Vdout0_4ck88 = 1.8 time = 890
.meas tran vdout0_4ck88 FIND v(dout0_4) AT=890.05n

* CHECK dout0_5 Vdout0_5ck88 = 1.8 time = 890
.meas tran vdout0_5ck88 FIND v(dout0_5) AT=890.05n

* CHECK dout0_6 Vdout0_6ck88 = 0 time = 890
.meas tran vdout0_6ck88 FIND v(dout0_6) AT=890.05n

* CHECK dout0_7 Vdout0_7ck88 = 0 time = 890
.meas tran vdout0_7ck88 FIND v(dout0_7) AT=890.05n

* CHECK dout0_8 Vdout0_8ck88 = 1.8 time = 890
.meas tran vdout0_8ck88 FIND v(dout0_8) AT=890.05n

* CHECK dout0_9 Vdout0_9ck88 = 1.8 time = 890
.meas tran vdout0_9ck88 FIND v(dout0_9) AT=890.05n

* CHECK dout0_10 Vdout0_10ck88 = 1.8 time = 890
.meas tran vdout0_10ck88 FIND v(dout0_10) AT=890.05n

* CHECK dout0_11 Vdout0_11ck88 = 1.8 time = 890
.meas tran vdout0_11ck88 FIND v(dout0_11) AT=890.05n

* CHECK dout0_12 Vdout0_12ck88 = 0 time = 890
.meas tran vdout0_12ck88 FIND v(dout0_12) AT=890.05n

* CHECK dout0_13 Vdout0_13ck88 = 1.8 time = 890
.meas tran vdout0_13ck88 FIND v(dout0_13) AT=890.05n

* CHECK dout0_14 Vdout0_14ck88 = 1.8 time = 890
.meas tran vdout0_14ck88 FIND v(dout0_14) AT=890.05n

* CHECK dout0_15 Vdout0_15ck88 = 0 time = 890
.meas tran vdout0_15ck88 FIND v(dout0_15) AT=890.05n

* CHECK dout0_16 Vdout0_16ck88 = 0 time = 890
.meas tran vdout0_16ck88 FIND v(dout0_16) AT=890.05n

* CHECK dout0_17 Vdout0_17ck88 = 1.8 time = 890
.meas tran vdout0_17ck88 FIND v(dout0_17) AT=890.05n

* CHECK dout0_18 Vdout0_18ck88 = 0 time = 890
.meas tran vdout0_18ck88 FIND v(dout0_18) AT=890.05n

* CHECK dout0_19 Vdout0_19ck88 = 0 time = 890
.meas tran vdout0_19ck88 FIND v(dout0_19) AT=890.05n

* CHECK dout0_20 Vdout0_20ck88 = 1.8 time = 890
.meas tran vdout0_20ck88 FIND v(dout0_20) AT=890.05n

* CHECK dout0_21 Vdout0_21ck88 = 0 time = 890
.meas tran vdout0_21ck88 FIND v(dout0_21) AT=890.05n

* CHECK dout0_22 Vdout0_22ck88 = 0 time = 890
.meas tran vdout0_22ck88 FIND v(dout0_22) AT=890.05n

* CHECK dout0_23 Vdout0_23ck88 = 0 time = 890
.meas tran vdout0_23ck88 FIND v(dout0_23) AT=890.05n

* CHECK dout0_24 Vdout0_24ck88 = 1.8 time = 890
.meas tran vdout0_24ck88 FIND v(dout0_24) AT=890.05n

* CHECK dout0_25 Vdout0_25ck88 = 0 time = 890
.meas tran vdout0_25ck88 FIND v(dout0_25) AT=890.05n

* CHECK dout0_26 Vdout0_26ck88 = 1.8 time = 890
.meas tran vdout0_26ck88 FIND v(dout0_26) AT=890.05n

* CHECK dout0_27 Vdout0_27ck88 = 1.8 time = 890
.meas tran vdout0_27ck88 FIND v(dout0_27) AT=890.05n

* CHECK dout0_28 Vdout0_28ck88 = 0 time = 890
.meas tran vdout0_28ck88 FIND v(dout0_28) AT=890.05n

* CHECK dout0_29 Vdout0_29ck88 = 1.8 time = 890
.meas tran vdout0_29ck88 FIND v(dout0_29) AT=890.05n

* CHECK dout0_30 Vdout0_30ck88 = 0 time = 890
.meas tran vdout0_30ck88 FIND v(dout0_30) AT=890.05n

* CHECK dout0_31 Vdout0_31ck88 = 1.8 time = 890
.meas tran vdout0_31ck88 FIND v(dout0_31) AT=890.05n

* CHECK dout0_32 Vdout0_32ck88 = 0 time = 890
.meas tran vdout0_32ck88 FIND v(dout0_32) AT=890.05n

* CHECK dout0_0 Vdout0_0ck90 = 1.8 time = 910
.meas tran vdout0_0ck90 FIND v(dout0_0) AT=910.05n

* CHECK dout0_1 Vdout0_1ck90 = 0 time = 910
.meas tran vdout0_1ck90 FIND v(dout0_1) AT=910.05n

* CHECK dout0_2 Vdout0_2ck90 = 0 time = 910
.meas tran vdout0_2ck90 FIND v(dout0_2) AT=910.05n

* CHECK dout0_3 Vdout0_3ck90 = 1.8 time = 910
.meas tran vdout0_3ck90 FIND v(dout0_3) AT=910.05n

* CHECK dout0_4 Vdout0_4ck90 = 1.8 time = 910
.meas tran vdout0_4ck90 FIND v(dout0_4) AT=910.05n

* CHECK dout0_5 Vdout0_5ck90 = 1.8 time = 910
.meas tran vdout0_5ck90 FIND v(dout0_5) AT=910.05n

* CHECK dout0_6 Vdout0_6ck90 = 0 time = 910
.meas tran vdout0_6ck90 FIND v(dout0_6) AT=910.05n

* CHECK dout0_7 Vdout0_7ck90 = 0 time = 910
.meas tran vdout0_7ck90 FIND v(dout0_7) AT=910.05n

* CHECK dout0_8 Vdout0_8ck90 = 1.8 time = 910
.meas tran vdout0_8ck90 FIND v(dout0_8) AT=910.05n

* CHECK dout0_9 Vdout0_9ck90 = 1.8 time = 910
.meas tran vdout0_9ck90 FIND v(dout0_9) AT=910.05n

* CHECK dout0_10 Vdout0_10ck90 = 1.8 time = 910
.meas tran vdout0_10ck90 FIND v(dout0_10) AT=910.05n

* CHECK dout0_11 Vdout0_11ck90 = 1.8 time = 910
.meas tran vdout0_11ck90 FIND v(dout0_11) AT=910.05n

* CHECK dout0_12 Vdout0_12ck90 = 0 time = 910
.meas tran vdout0_12ck90 FIND v(dout0_12) AT=910.05n

* CHECK dout0_13 Vdout0_13ck90 = 1.8 time = 910
.meas tran vdout0_13ck90 FIND v(dout0_13) AT=910.05n

* CHECK dout0_14 Vdout0_14ck90 = 1.8 time = 910
.meas tran vdout0_14ck90 FIND v(dout0_14) AT=910.05n

* CHECK dout0_15 Vdout0_15ck90 = 0 time = 910
.meas tran vdout0_15ck90 FIND v(dout0_15) AT=910.05n

* CHECK dout0_16 Vdout0_16ck90 = 0 time = 910
.meas tran vdout0_16ck90 FIND v(dout0_16) AT=910.05n

* CHECK dout0_17 Vdout0_17ck90 = 1.8 time = 910
.meas tran vdout0_17ck90 FIND v(dout0_17) AT=910.05n

* CHECK dout0_18 Vdout0_18ck90 = 0 time = 910
.meas tran vdout0_18ck90 FIND v(dout0_18) AT=910.05n

* CHECK dout0_19 Vdout0_19ck90 = 0 time = 910
.meas tran vdout0_19ck90 FIND v(dout0_19) AT=910.05n

* CHECK dout0_20 Vdout0_20ck90 = 1.8 time = 910
.meas tran vdout0_20ck90 FIND v(dout0_20) AT=910.05n

* CHECK dout0_21 Vdout0_21ck90 = 0 time = 910
.meas tran vdout0_21ck90 FIND v(dout0_21) AT=910.05n

* CHECK dout0_22 Vdout0_22ck90 = 0 time = 910
.meas tran vdout0_22ck90 FIND v(dout0_22) AT=910.05n

* CHECK dout0_23 Vdout0_23ck90 = 0 time = 910
.meas tran vdout0_23ck90 FIND v(dout0_23) AT=910.05n

* CHECK dout0_24 Vdout0_24ck90 = 1.8 time = 910
.meas tran vdout0_24ck90 FIND v(dout0_24) AT=910.05n

* CHECK dout0_25 Vdout0_25ck90 = 0 time = 910
.meas tran vdout0_25ck90 FIND v(dout0_25) AT=910.05n

* CHECK dout0_26 Vdout0_26ck90 = 1.8 time = 910
.meas tran vdout0_26ck90 FIND v(dout0_26) AT=910.05n

* CHECK dout0_27 Vdout0_27ck90 = 1.8 time = 910
.meas tran vdout0_27ck90 FIND v(dout0_27) AT=910.05n

* CHECK dout0_28 Vdout0_28ck90 = 0 time = 910
.meas tran vdout0_28ck90 FIND v(dout0_28) AT=910.05n

* CHECK dout0_29 Vdout0_29ck90 = 1.8 time = 910
.meas tran vdout0_29ck90 FIND v(dout0_29) AT=910.05n

* CHECK dout0_30 Vdout0_30ck90 = 0 time = 910
.meas tran vdout0_30ck90 FIND v(dout0_30) AT=910.05n

* CHECK dout0_31 Vdout0_31ck90 = 1.8 time = 910
.meas tran vdout0_31ck90 FIND v(dout0_31) AT=910.05n

* CHECK dout0_32 Vdout0_32ck90 = 0 time = 910
.meas tran vdout0_32ck90 FIND v(dout0_32) AT=910.05n

* CHECK dout0_0 Vdout0_0ck91 = 1.8 time = 920
.meas tran vdout0_0ck91 FIND v(dout0_0) AT=920.05n

* CHECK dout0_1 Vdout0_1ck91 = 1.8 time = 920
.meas tran vdout0_1ck91 FIND v(dout0_1) AT=920.05n

* CHECK dout0_2 Vdout0_2ck91 = 1.8 time = 920
.meas tran vdout0_2ck91 FIND v(dout0_2) AT=920.05n

* CHECK dout0_3 Vdout0_3ck91 = 0 time = 920
.meas tran vdout0_3ck91 FIND v(dout0_3) AT=920.05n

* CHECK dout0_4 Vdout0_4ck91 = 1.8 time = 920
.meas tran vdout0_4ck91 FIND v(dout0_4) AT=920.05n

* CHECK dout0_5 Vdout0_5ck91 = 0 time = 920
.meas tran vdout0_5ck91 FIND v(dout0_5) AT=920.05n

* CHECK dout0_6 Vdout0_6ck91 = 0 time = 920
.meas tran vdout0_6ck91 FIND v(dout0_6) AT=920.05n

* CHECK dout0_7 Vdout0_7ck91 = 1.8 time = 920
.meas tran vdout0_7ck91 FIND v(dout0_7) AT=920.05n

* CHECK dout0_8 Vdout0_8ck91 = 1.8 time = 920
.meas tran vdout0_8ck91 FIND v(dout0_8) AT=920.05n

* CHECK dout0_9 Vdout0_9ck91 = 1.8 time = 920
.meas tran vdout0_9ck91 FIND v(dout0_9) AT=920.05n

* CHECK dout0_10 Vdout0_10ck91 = 0 time = 920
.meas tran vdout0_10ck91 FIND v(dout0_10) AT=920.05n

* CHECK dout0_11 Vdout0_11ck91 = 0 time = 920
.meas tran vdout0_11ck91 FIND v(dout0_11) AT=920.05n

* CHECK dout0_12 Vdout0_12ck91 = 0 time = 920
.meas tran vdout0_12ck91 FIND v(dout0_12) AT=920.05n

* CHECK dout0_13 Vdout0_13ck91 = 1.8 time = 920
.meas tran vdout0_13ck91 FIND v(dout0_13) AT=920.05n

* CHECK dout0_14 Vdout0_14ck91 = 0 time = 920
.meas tran vdout0_14ck91 FIND v(dout0_14) AT=920.05n

* CHECK dout0_15 Vdout0_15ck91 = 1.8 time = 920
.meas tran vdout0_15ck91 FIND v(dout0_15) AT=920.05n

* CHECK dout0_16 Vdout0_16ck91 = 1.8 time = 920
.meas tran vdout0_16ck91 FIND v(dout0_16) AT=920.05n

* CHECK dout0_17 Vdout0_17ck91 = 0 time = 920
.meas tran vdout0_17ck91 FIND v(dout0_17) AT=920.05n

* CHECK dout0_18 Vdout0_18ck91 = 0 time = 920
.meas tran vdout0_18ck91 FIND v(dout0_18) AT=920.05n

* CHECK dout0_19 Vdout0_19ck91 = 0 time = 920
.meas tran vdout0_19ck91 FIND v(dout0_19) AT=920.05n

* CHECK dout0_20 Vdout0_20ck91 = 0 time = 920
.meas tran vdout0_20ck91 FIND v(dout0_20) AT=920.05n

* CHECK dout0_21 Vdout0_21ck91 = 1.8 time = 920
.meas tran vdout0_21ck91 FIND v(dout0_21) AT=920.05n

* CHECK dout0_22 Vdout0_22ck91 = 1.8 time = 920
.meas tran vdout0_22ck91 FIND v(dout0_22) AT=920.05n

* CHECK dout0_23 Vdout0_23ck91 = 0 time = 920
.meas tran vdout0_23ck91 FIND v(dout0_23) AT=920.05n

* CHECK dout0_24 Vdout0_24ck91 = 0 time = 920
.meas tran vdout0_24ck91 FIND v(dout0_24) AT=920.05n

* CHECK dout0_25 Vdout0_25ck91 = 1.8 time = 920
.meas tran vdout0_25ck91 FIND v(dout0_25) AT=920.05n

* CHECK dout0_26 Vdout0_26ck91 = 0 time = 920
.meas tran vdout0_26ck91 FIND v(dout0_26) AT=920.05n

* CHECK dout0_27 Vdout0_27ck91 = 1.8 time = 920
.meas tran vdout0_27ck91 FIND v(dout0_27) AT=920.05n

* CHECK dout0_28 Vdout0_28ck91 = 0 time = 920
.meas tran vdout0_28ck91 FIND v(dout0_28) AT=920.05n

* CHECK dout0_29 Vdout0_29ck91 = 1.8 time = 920
.meas tran vdout0_29ck91 FIND v(dout0_29) AT=920.05n

* CHECK dout0_30 Vdout0_30ck91 = 0 time = 920
.meas tran vdout0_30ck91 FIND v(dout0_30) AT=920.05n

* CHECK dout0_31 Vdout0_31ck91 = 0 time = 920
.meas tran vdout0_31ck91 FIND v(dout0_31) AT=920.05n

* CHECK dout0_32 Vdout0_32ck91 = 0 time = 920
.meas tran vdout0_32ck91 FIND v(dout0_32) AT=920.05n

* CHECK dout0_0 Vdout0_0ck93 = 0 time = 940
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=940.05n

* CHECK dout0_1 Vdout0_1ck93 = 1.8 time = 940
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=940.05n

* CHECK dout0_2 Vdout0_2ck93 = 1.8 time = 940
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=940.05n

* CHECK dout0_3 Vdout0_3ck93 = 1.8 time = 940
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=940.05n

* CHECK dout0_4 Vdout0_4ck93 = 1.8 time = 940
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=940.05n

* CHECK dout0_5 Vdout0_5ck93 = 1.8 time = 940
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=940.05n

* CHECK dout0_6 Vdout0_6ck93 = 1.8 time = 940
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=940.05n

* CHECK dout0_7 Vdout0_7ck93 = 0 time = 940
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=940.05n

* CHECK dout0_8 Vdout0_8ck93 = 1.8 time = 940
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=940.05n

* CHECK dout0_9 Vdout0_9ck93 = 0 time = 940
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=940.05n

* CHECK dout0_10 Vdout0_10ck93 = 1.8 time = 940
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=940.05n

* CHECK dout0_11 Vdout0_11ck93 = 1.8 time = 940
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=940.05n

* CHECK dout0_12 Vdout0_12ck93 = 1.8 time = 940
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=940.05n

* CHECK dout0_13 Vdout0_13ck93 = 0 time = 940
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=940.05n

* CHECK dout0_14 Vdout0_14ck93 = 0 time = 940
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=940.05n

* CHECK dout0_15 Vdout0_15ck93 = 1.8 time = 940
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=940.05n

* CHECK dout0_16 Vdout0_16ck93 = 0 time = 940
.meas tran vdout0_16ck93 FIND v(dout0_16) AT=940.05n

* CHECK dout0_17 Vdout0_17ck93 = 1.8 time = 940
.meas tran vdout0_17ck93 FIND v(dout0_17) AT=940.05n

* CHECK dout0_18 Vdout0_18ck93 = 0 time = 940
.meas tran vdout0_18ck93 FIND v(dout0_18) AT=940.05n

* CHECK dout0_19 Vdout0_19ck93 = 0 time = 940
.meas tran vdout0_19ck93 FIND v(dout0_19) AT=940.05n

* CHECK dout0_20 Vdout0_20ck93 = 1.8 time = 940
.meas tran vdout0_20ck93 FIND v(dout0_20) AT=940.05n

* CHECK dout0_21 Vdout0_21ck93 = 1.8 time = 940
.meas tran vdout0_21ck93 FIND v(dout0_21) AT=940.05n

* CHECK dout0_22 Vdout0_22ck93 = 1.8 time = 940
.meas tran vdout0_22ck93 FIND v(dout0_22) AT=940.05n

* CHECK dout0_23 Vdout0_23ck93 = 0 time = 940
.meas tran vdout0_23ck93 FIND v(dout0_23) AT=940.05n

* CHECK dout0_24 Vdout0_24ck93 = 0 time = 940
.meas tran vdout0_24ck93 FIND v(dout0_24) AT=940.05n

* CHECK dout0_25 Vdout0_25ck93 = 0 time = 940
.meas tran vdout0_25ck93 FIND v(dout0_25) AT=940.05n

* CHECK dout0_26 Vdout0_26ck93 = 1.8 time = 940
.meas tran vdout0_26ck93 FIND v(dout0_26) AT=940.05n

* CHECK dout0_27 Vdout0_27ck93 = 0 time = 940
.meas tran vdout0_27ck93 FIND v(dout0_27) AT=940.05n

* CHECK dout0_28 Vdout0_28ck93 = 1.8 time = 940
.meas tran vdout0_28ck93 FIND v(dout0_28) AT=940.05n

* CHECK dout0_29 Vdout0_29ck93 = 0 time = 940
.meas tran vdout0_29ck93 FIND v(dout0_29) AT=940.05n

* CHECK dout0_30 Vdout0_30ck93 = 0 time = 940
.meas tran vdout0_30ck93 FIND v(dout0_30) AT=940.05n

* CHECK dout0_31 Vdout0_31ck93 = 1.8 time = 940
.meas tran vdout0_31ck93 FIND v(dout0_31) AT=940.05n

* CHECK dout0_32 Vdout0_32ck93 = 0 time = 940
.meas tran vdout0_32ck93 FIND v(dout0_32) AT=940.05n

* CHECK dout0_0 Vdout0_0ck96 = 0 time = 970
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=970.05n

* CHECK dout0_1 Vdout0_1ck96 = 1.8 time = 970
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=970.05n

* CHECK dout0_2 Vdout0_2ck96 = 1.8 time = 970
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=970.05n

* CHECK dout0_3 Vdout0_3ck96 = 1.8 time = 970
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=970.05n

* CHECK dout0_4 Vdout0_4ck96 = 1.8 time = 970
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=970.05n

* CHECK dout0_5 Vdout0_5ck96 = 1.8 time = 970
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=970.05n

* CHECK dout0_6 Vdout0_6ck96 = 1.8 time = 970
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=970.05n

* CHECK dout0_7 Vdout0_7ck96 = 0 time = 970
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=970.05n

* CHECK dout0_8 Vdout0_8ck96 = 1.8 time = 970
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=970.05n

* CHECK dout0_9 Vdout0_9ck96 = 0 time = 970
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=970.05n

* CHECK dout0_10 Vdout0_10ck96 = 1.8 time = 970
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=970.05n

* CHECK dout0_11 Vdout0_11ck96 = 1.8 time = 970
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=970.05n

* CHECK dout0_12 Vdout0_12ck96 = 1.8 time = 970
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=970.05n

* CHECK dout0_13 Vdout0_13ck96 = 0 time = 970
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=970.05n

* CHECK dout0_14 Vdout0_14ck96 = 0 time = 970
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=970.05n

* CHECK dout0_15 Vdout0_15ck96 = 1.8 time = 970
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=970.05n

* CHECK dout0_16 Vdout0_16ck96 = 0 time = 970
.meas tran vdout0_16ck96 FIND v(dout0_16) AT=970.05n

* CHECK dout0_17 Vdout0_17ck96 = 1.8 time = 970
.meas tran vdout0_17ck96 FIND v(dout0_17) AT=970.05n

* CHECK dout0_18 Vdout0_18ck96 = 0 time = 970
.meas tran vdout0_18ck96 FIND v(dout0_18) AT=970.05n

* CHECK dout0_19 Vdout0_19ck96 = 0 time = 970
.meas tran vdout0_19ck96 FIND v(dout0_19) AT=970.05n

* CHECK dout0_20 Vdout0_20ck96 = 1.8 time = 970
.meas tran vdout0_20ck96 FIND v(dout0_20) AT=970.05n

* CHECK dout0_21 Vdout0_21ck96 = 1.8 time = 970
.meas tran vdout0_21ck96 FIND v(dout0_21) AT=970.05n

* CHECK dout0_22 Vdout0_22ck96 = 1.8 time = 970
.meas tran vdout0_22ck96 FIND v(dout0_22) AT=970.05n

* CHECK dout0_23 Vdout0_23ck96 = 0 time = 970
.meas tran vdout0_23ck96 FIND v(dout0_23) AT=970.05n

* CHECK dout0_24 Vdout0_24ck96 = 0 time = 970
.meas tran vdout0_24ck96 FIND v(dout0_24) AT=970.05n

* CHECK dout0_25 Vdout0_25ck96 = 0 time = 970
.meas tran vdout0_25ck96 FIND v(dout0_25) AT=970.05n

* CHECK dout0_26 Vdout0_26ck96 = 1.8 time = 970
.meas tran vdout0_26ck96 FIND v(dout0_26) AT=970.05n

* CHECK dout0_27 Vdout0_27ck96 = 0 time = 970
.meas tran vdout0_27ck96 FIND v(dout0_27) AT=970.05n

* CHECK dout0_28 Vdout0_28ck96 = 1.8 time = 970
.meas tran vdout0_28ck96 FIND v(dout0_28) AT=970.05n

* CHECK dout0_29 Vdout0_29ck96 = 0 time = 970
.meas tran vdout0_29ck96 FIND v(dout0_29) AT=970.05n

* CHECK dout0_30 Vdout0_30ck96 = 0 time = 970
.meas tran vdout0_30ck96 FIND v(dout0_30) AT=970.05n

* CHECK dout0_31 Vdout0_31ck96 = 1.8 time = 970
.meas tran vdout0_31ck96 FIND v(dout0_31) AT=970.05n

* CHECK dout0_32 Vdout0_32ck96 = 0 time = 970
.meas tran vdout0_32ck96 FIND v(dout0_32) AT=970.05n

* CHECK dout0_0 Vdout0_0ck97 = 0 time = 980
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=980.05n

* CHECK dout0_1 Vdout0_1ck97 = 1.8 time = 980
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=980.05n

* CHECK dout0_2 Vdout0_2ck97 = 1.8 time = 980
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=980.05n

* CHECK dout0_3 Vdout0_3ck97 = 1.8 time = 980
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=980.05n

* CHECK dout0_4 Vdout0_4ck97 = 1.8 time = 980
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=980.05n

* CHECK dout0_5 Vdout0_5ck97 = 1.8 time = 980
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=980.05n

* CHECK dout0_6 Vdout0_6ck97 = 1.8 time = 980
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=980.05n

* CHECK dout0_7 Vdout0_7ck97 = 0 time = 980
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=980.05n

* CHECK dout0_8 Vdout0_8ck97 = 1.8 time = 980
.meas tran vdout0_8ck97 FIND v(dout0_8) AT=980.05n

* CHECK dout0_9 Vdout0_9ck97 = 0 time = 980
.meas tran vdout0_9ck97 FIND v(dout0_9) AT=980.05n

* CHECK dout0_10 Vdout0_10ck97 = 1.8 time = 980
.meas tran vdout0_10ck97 FIND v(dout0_10) AT=980.05n

* CHECK dout0_11 Vdout0_11ck97 = 1.8 time = 980
.meas tran vdout0_11ck97 FIND v(dout0_11) AT=980.05n

* CHECK dout0_12 Vdout0_12ck97 = 1.8 time = 980
.meas tran vdout0_12ck97 FIND v(dout0_12) AT=980.05n

* CHECK dout0_13 Vdout0_13ck97 = 0 time = 980
.meas tran vdout0_13ck97 FIND v(dout0_13) AT=980.05n

* CHECK dout0_14 Vdout0_14ck97 = 0 time = 980
.meas tran vdout0_14ck97 FIND v(dout0_14) AT=980.05n

* CHECK dout0_15 Vdout0_15ck97 = 1.8 time = 980
.meas tran vdout0_15ck97 FIND v(dout0_15) AT=980.05n

* CHECK dout0_16 Vdout0_16ck97 = 0 time = 980
.meas tran vdout0_16ck97 FIND v(dout0_16) AT=980.05n

* CHECK dout0_17 Vdout0_17ck97 = 1.8 time = 980
.meas tran vdout0_17ck97 FIND v(dout0_17) AT=980.05n

* CHECK dout0_18 Vdout0_18ck97 = 0 time = 980
.meas tran vdout0_18ck97 FIND v(dout0_18) AT=980.05n

* CHECK dout0_19 Vdout0_19ck97 = 0 time = 980
.meas tran vdout0_19ck97 FIND v(dout0_19) AT=980.05n

* CHECK dout0_20 Vdout0_20ck97 = 1.8 time = 980
.meas tran vdout0_20ck97 FIND v(dout0_20) AT=980.05n

* CHECK dout0_21 Vdout0_21ck97 = 1.8 time = 980
.meas tran vdout0_21ck97 FIND v(dout0_21) AT=980.05n

* CHECK dout0_22 Vdout0_22ck97 = 1.8 time = 980
.meas tran vdout0_22ck97 FIND v(dout0_22) AT=980.05n

* CHECK dout0_23 Vdout0_23ck97 = 0 time = 980
.meas tran vdout0_23ck97 FIND v(dout0_23) AT=980.05n

* CHECK dout0_24 Vdout0_24ck97 = 0 time = 980
.meas tran vdout0_24ck97 FIND v(dout0_24) AT=980.05n

* CHECK dout0_25 Vdout0_25ck97 = 0 time = 980
.meas tran vdout0_25ck97 FIND v(dout0_25) AT=980.05n

* CHECK dout0_26 Vdout0_26ck97 = 1.8 time = 980
.meas tran vdout0_26ck97 FIND v(dout0_26) AT=980.05n

* CHECK dout0_27 Vdout0_27ck97 = 0 time = 980
.meas tran vdout0_27ck97 FIND v(dout0_27) AT=980.05n

* CHECK dout0_28 Vdout0_28ck97 = 1.8 time = 980
.meas tran vdout0_28ck97 FIND v(dout0_28) AT=980.05n

* CHECK dout0_29 Vdout0_29ck97 = 0 time = 980
.meas tran vdout0_29ck97 FIND v(dout0_29) AT=980.05n

* CHECK dout0_30 Vdout0_30ck97 = 0 time = 980
.meas tran vdout0_30ck97 FIND v(dout0_30) AT=980.05n

* CHECK dout0_31 Vdout0_31ck97 = 1.8 time = 980
.meas tran vdout0_31ck97 FIND v(dout0_31) AT=980.05n

* CHECK dout0_32 Vdout0_32ck97 = 0 time = 980
.meas tran vdout0_32ck97 FIND v(dout0_32) AT=980.05n

* CHECK dout0_0 Vdout0_0ck99 = 1.8 time = 1000
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=1000.05n

* CHECK dout0_1 Vdout0_1ck99 = 0 time = 1000
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=1000.05n

* CHECK dout0_2 Vdout0_2ck99 = 1.8 time = 1000
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=1000.05n

* CHECK dout0_3 Vdout0_3ck99 = 1.8 time = 1000
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=1000.05n

* CHECK dout0_4 Vdout0_4ck99 = 1.8 time = 1000
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=1000.05n

* CHECK dout0_5 Vdout0_5ck99 = 1.8 time = 1000
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=1000.05n

* CHECK dout0_6 Vdout0_6ck99 = 0 time = 1000
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=1000.05n

* CHECK dout0_7 Vdout0_7ck99 = 0 time = 1000
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=1000.05n

* CHECK dout0_8 Vdout0_8ck99 = 1.8 time = 1000
.meas tran vdout0_8ck99 FIND v(dout0_8) AT=1000.05n

* CHECK dout0_9 Vdout0_9ck99 = 0 time = 1000
.meas tran vdout0_9ck99 FIND v(dout0_9) AT=1000.05n

* CHECK dout0_10 Vdout0_10ck99 = 1.8 time = 1000
.meas tran vdout0_10ck99 FIND v(dout0_10) AT=1000.05n

* CHECK dout0_11 Vdout0_11ck99 = 1.8 time = 1000
.meas tran vdout0_11ck99 FIND v(dout0_11) AT=1000.05n

* CHECK dout0_12 Vdout0_12ck99 = 0 time = 1000
.meas tran vdout0_12ck99 FIND v(dout0_12) AT=1000.05n

* CHECK dout0_13 Vdout0_13ck99 = 1.8 time = 1000
.meas tran vdout0_13ck99 FIND v(dout0_13) AT=1000.05n

* CHECK dout0_14 Vdout0_14ck99 = 0 time = 1000
.meas tran vdout0_14ck99 FIND v(dout0_14) AT=1000.05n

* CHECK dout0_15 Vdout0_15ck99 = 1.8 time = 1000
.meas tran vdout0_15ck99 FIND v(dout0_15) AT=1000.05n

* CHECK dout0_16 Vdout0_16ck99 = 0 time = 1000
.meas tran vdout0_16ck99 FIND v(dout0_16) AT=1000.05n

* CHECK dout0_17 Vdout0_17ck99 = 1.8 time = 1000
.meas tran vdout0_17ck99 FIND v(dout0_17) AT=1000.05n

* CHECK dout0_18 Vdout0_18ck99 = 1.8 time = 1000
.meas tran vdout0_18ck99 FIND v(dout0_18) AT=1000.05n

* CHECK dout0_19 Vdout0_19ck99 = 1.8 time = 1000
.meas tran vdout0_19ck99 FIND v(dout0_19) AT=1000.05n

* CHECK dout0_20 Vdout0_20ck99 = 1.8 time = 1000
.meas tran vdout0_20ck99 FIND v(dout0_20) AT=1000.05n

* CHECK dout0_21 Vdout0_21ck99 = 0 time = 1000
.meas tran vdout0_21ck99 FIND v(dout0_21) AT=1000.05n

* CHECK dout0_22 Vdout0_22ck99 = 0 time = 1000
.meas tran vdout0_22ck99 FIND v(dout0_22) AT=1000.05n

* CHECK dout0_23 Vdout0_23ck99 = 0 time = 1000
.meas tran vdout0_23ck99 FIND v(dout0_23) AT=1000.05n

* CHECK dout0_24 Vdout0_24ck99 = 1.8 time = 1000
.meas tran vdout0_24ck99 FIND v(dout0_24) AT=1000.05n

* CHECK dout0_25 Vdout0_25ck99 = 0 time = 1000
.meas tran vdout0_25ck99 FIND v(dout0_25) AT=1000.05n

* CHECK dout0_26 Vdout0_26ck99 = 0 time = 1000
.meas tran vdout0_26ck99 FIND v(dout0_26) AT=1000.05n

* CHECK dout0_27 Vdout0_27ck99 = 1.8 time = 1000
.meas tran vdout0_27ck99 FIND v(dout0_27) AT=1000.05n

* CHECK dout0_28 Vdout0_28ck99 = 0 time = 1000
.meas tran vdout0_28ck99 FIND v(dout0_28) AT=1000.05n

* CHECK dout0_29 Vdout0_29ck99 = 0 time = 1000
.meas tran vdout0_29ck99 FIND v(dout0_29) AT=1000.05n

* CHECK dout0_30 Vdout0_30ck99 = 0 time = 1000
.meas tran vdout0_30ck99 FIND v(dout0_30) AT=1000.05n

* CHECK dout0_31 Vdout0_31ck99 = 0 time = 1000
.meas tran vdout0_31ck99 FIND v(dout0_31) AT=1000.05n

* CHECK dout0_32 Vdout0_32ck99 = 0 time = 1000
.meas tran vdout0_32ck99 FIND v(dout0_32) AT=1000.05n

* CHECK dout0_0 Vdout0_0ck101 = 1.8 time = 1020
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=1020.05n

* CHECK dout0_1 Vdout0_1ck101 = 1.8 time = 1020
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=1020.05n

* CHECK dout0_2 Vdout0_2ck101 = 1.8 time = 1020
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=1020.05n

* CHECK dout0_3 Vdout0_3ck101 = 0 time = 1020
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=1020.05n

* CHECK dout0_4 Vdout0_4ck101 = 1.8 time = 1020
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=1020.05n

* CHECK dout0_5 Vdout0_5ck101 = 0 time = 1020
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=1020.05n

* CHECK dout0_6 Vdout0_6ck101 = 0 time = 1020
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=1020.05n

* CHECK dout0_7 Vdout0_7ck101 = 1.8 time = 1020
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=1020.05n

* CHECK dout0_8 Vdout0_8ck101 = 1.8 time = 1020
.meas tran vdout0_8ck101 FIND v(dout0_8) AT=1020.05n

* CHECK dout0_9 Vdout0_9ck101 = 1.8 time = 1020
.meas tran vdout0_9ck101 FIND v(dout0_9) AT=1020.05n

* CHECK dout0_10 Vdout0_10ck101 = 0 time = 1020
.meas tran vdout0_10ck101 FIND v(dout0_10) AT=1020.05n

* CHECK dout0_11 Vdout0_11ck101 = 0 time = 1020
.meas tran vdout0_11ck101 FIND v(dout0_11) AT=1020.05n

* CHECK dout0_12 Vdout0_12ck101 = 0 time = 1020
.meas tran vdout0_12ck101 FIND v(dout0_12) AT=1020.05n

* CHECK dout0_13 Vdout0_13ck101 = 1.8 time = 1020
.meas tran vdout0_13ck101 FIND v(dout0_13) AT=1020.05n

* CHECK dout0_14 Vdout0_14ck101 = 0 time = 1020
.meas tran vdout0_14ck101 FIND v(dout0_14) AT=1020.05n

* CHECK dout0_15 Vdout0_15ck101 = 1.8 time = 1020
.meas tran vdout0_15ck101 FIND v(dout0_15) AT=1020.05n

* CHECK dout0_16 Vdout0_16ck101 = 1.8 time = 1020
.meas tran vdout0_16ck101 FIND v(dout0_16) AT=1020.05n

* CHECK dout0_17 Vdout0_17ck101 = 0 time = 1020
.meas tran vdout0_17ck101 FIND v(dout0_17) AT=1020.05n

* CHECK dout0_18 Vdout0_18ck101 = 0 time = 1020
.meas tran vdout0_18ck101 FIND v(dout0_18) AT=1020.05n

* CHECK dout0_19 Vdout0_19ck101 = 0 time = 1020
.meas tran vdout0_19ck101 FIND v(dout0_19) AT=1020.05n

* CHECK dout0_20 Vdout0_20ck101 = 0 time = 1020
.meas tran vdout0_20ck101 FIND v(dout0_20) AT=1020.05n

* CHECK dout0_21 Vdout0_21ck101 = 1.8 time = 1020
.meas tran vdout0_21ck101 FIND v(dout0_21) AT=1020.05n

* CHECK dout0_22 Vdout0_22ck101 = 1.8 time = 1020
.meas tran vdout0_22ck101 FIND v(dout0_22) AT=1020.05n

* CHECK dout0_23 Vdout0_23ck101 = 0 time = 1020
.meas tran vdout0_23ck101 FIND v(dout0_23) AT=1020.05n

* CHECK dout0_24 Vdout0_24ck101 = 0 time = 1020
.meas tran vdout0_24ck101 FIND v(dout0_24) AT=1020.05n

* CHECK dout0_25 Vdout0_25ck101 = 1.8 time = 1020
.meas tran vdout0_25ck101 FIND v(dout0_25) AT=1020.05n

* CHECK dout0_26 Vdout0_26ck101 = 0 time = 1020
.meas tran vdout0_26ck101 FIND v(dout0_26) AT=1020.05n

* CHECK dout0_27 Vdout0_27ck101 = 1.8 time = 1020
.meas tran vdout0_27ck101 FIND v(dout0_27) AT=1020.05n

* CHECK dout0_28 Vdout0_28ck101 = 0 time = 1020
.meas tran vdout0_28ck101 FIND v(dout0_28) AT=1020.05n

* CHECK dout0_29 Vdout0_29ck101 = 1.8 time = 1020
.meas tran vdout0_29ck101 FIND v(dout0_29) AT=1020.05n

* CHECK dout0_30 Vdout0_30ck101 = 0 time = 1020
.meas tran vdout0_30ck101 FIND v(dout0_30) AT=1020.05n

* CHECK dout0_31 Vdout0_31ck101 = 0 time = 1020
.meas tran vdout0_31ck101 FIND v(dout0_31) AT=1020.05n

* CHECK dout0_32 Vdout0_32ck101 = 0 time = 1020
.meas tran vdout0_32ck101 FIND v(dout0_32) AT=1020.05n

* CHECK dout0_0 Vdout0_0ck102 = 1.8 time = 1030
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=1030.05n

* CHECK dout0_1 Vdout0_1ck102 = 0 time = 1030
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=1030.05n

* CHECK dout0_2 Vdout0_2ck102 = 1.8 time = 1030
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=1030.05n

* CHECK dout0_3 Vdout0_3ck102 = 1.8 time = 1030
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=1030.05n

* CHECK dout0_4 Vdout0_4ck102 = 1.8 time = 1030
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=1030.05n

* CHECK dout0_5 Vdout0_5ck102 = 1.8 time = 1030
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=1030.05n

* CHECK dout0_6 Vdout0_6ck102 = 0 time = 1030
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=1030.05n

* CHECK dout0_7 Vdout0_7ck102 = 0 time = 1030
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=1030.05n

* CHECK dout0_8 Vdout0_8ck102 = 1.8 time = 1030
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=1030.05n

* CHECK dout0_9 Vdout0_9ck102 = 0 time = 1030
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=1030.05n

* CHECK dout0_10 Vdout0_10ck102 = 1.8 time = 1030
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=1030.05n

* CHECK dout0_11 Vdout0_11ck102 = 1.8 time = 1030
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=1030.05n

* CHECK dout0_12 Vdout0_12ck102 = 0 time = 1030
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=1030.05n

* CHECK dout0_13 Vdout0_13ck102 = 1.8 time = 1030
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=1030.05n

* CHECK dout0_14 Vdout0_14ck102 = 0 time = 1030
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=1030.05n

* CHECK dout0_15 Vdout0_15ck102 = 1.8 time = 1030
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=1030.05n

* CHECK dout0_16 Vdout0_16ck102 = 0 time = 1030
.meas tran vdout0_16ck102 FIND v(dout0_16) AT=1030.05n

* CHECK dout0_17 Vdout0_17ck102 = 1.8 time = 1030
.meas tran vdout0_17ck102 FIND v(dout0_17) AT=1030.05n

* CHECK dout0_18 Vdout0_18ck102 = 1.8 time = 1030
.meas tran vdout0_18ck102 FIND v(dout0_18) AT=1030.05n

* CHECK dout0_19 Vdout0_19ck102 = 1.8 time = 1030
.meas tran vdout0_19ck102 FIND v(dout0_19) AT=1030.05n

* CHECK dout0_20 Vdout0_20ck102 = 1.8 time = 1030
.meas tran vdout0_20ck102 FIND v(dout0_20) AT=1030.05n

* CHECK dout0_21 Vdout0_21ck102 = 0 time = 1030
.meas tran vdout0_21ck102 FIND v(dout0_21) AT=1030.05n

* CHECK dout0_22 Vdout0_22ck102 = 0 time = 1030
.meas tran vdout0_22ck102 FIND v(dout0_22) AT=1030.05n

* CHECK dout0_23 Vdout0_23ck102 = 0 time = 1030
.meas tran vdout0_23ck102 FIND v(dout0_23) AT=1030.05n

* CHECK dout0_24 Vdout0_24ck102 = 1.8 time = 1030
.meas tran vdout0_24ck102 FIND v(dout0_24) AT=1030.05n

* CHECK dout0_25 Vdout0_25ck102 = 0 time = 1030
.meas tran vdout0_25ck102 FIND v(dout0_25) AT=1030.05n

* CHECK dout0_26 Vdout0_26ck102 = 0 time = 1030
.meas tran vdout0_26ck102 FIND v(dout0_26) AT=1030.05n

* CHECK dout0_27 Vdout0_27ck102 = 1.8 time = 1030
.meas tran vdout0_27ck102 FIND v(dout0_27) AT=1030.05n

* CHECK dout0_28 Vdout0_28ck102 = 0 time = 1030
.meas tran vdout0_28ck102 FIND v(dout0_28) AT=1030.05n

* CHECK dout0_29 Vdout0_29ck102 = 0 time = 1030
.meas tran vdout0_29ck102 FIND v(dout0_29) AT=1030.05n

* CHECK dout0_30 Vdout0_30ck102 = 0 time = 1030
.meas tran vdout0_30ck102 FIND v(dout0_30) AT=1030.05n

* CHECK dout0_31 Vdout0_31ck102 = 0 time = 1030
.meas tran vdout0_31ck102 FIND v(dout0_31) AT=1030.05n

* CHECK dout0_32 Vdout0_32ck102 = 0 time = 1030
.meas tran vdout0_32ck102 FIND v(dout0_32) AT=1030.05n

* CHECK dout0_0 Vdout0_0ck103 = 1.8 time = 1040
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=1040.05n

* CHECK dout0_1 Vdout0_1ck103 = 1.8 time = 1040
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=1040.05n

* CHECK dout0_2 Vdout0_2ck103 = 1.8 time = 1040
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=1040.05n

* CHECK dout0_3 Vdout0_3ck103 = 0 time = 1040
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=1040.05n

* CHECK dout0_4 Vdout0_4ck103 = 1.8 time = 1040
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=1040.05n

* CHECK dout0_5 Vdout0_5ck103 = 0 time = 1040
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=1040.05n

* CHECK dout0_6 Vdout0_6ck103 = 0 time = 1040
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=1040.05n

* CHECK dout0_7 Vdout0_7ck103 = 1.8 time = 1040
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=1040.05n

* CHECK dout0_8 Vdout0_8ck103 = 1.8 time = 1040
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=1040.05n

* CHECK dout0_9 Vdout0_9ck103 = 1.8 time = 1040
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=1040.05n

* CHECK dout0_10 Vdout0_10ck103 = 0 time = 1040
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=1040.05n

* CHECK dout0_11 Vdout0_11ck103 = 0 time = 1040
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=1040.05n

* CHECK dout0_12 Vdout0_12ck103 = 0 time = 1040
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=1040.05n

* CHECK dout0_13 Vdout0_13ck103 = 1.8 time = 1040
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=1040.05n

* CHECK dout0_14 Vdout0_14ck103 = 0 time = 1040
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=1040.05n

* CHECK dout0_15 Vdout0_15ck103 = 1.8 time = 1040
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=1040.05n

* CHECK dout0_16 Vdout0_16ck103 = 1.8 time = 1040
.meas tran vdout0_16ck103 FIND v(dout0_16) AT=1040.05n

* CHECK dout0_17 Vdout0_17ck103 = 0 time = 1040
.meas tran vdout0_17ck103 FIND v(dout0_17) AT=1040.05n

* CHECK dout0_18 Vdout0_18ck103 = 0 time = 1040
.meas tran vdout0_18ck103 FIND v(dout0_18) AT=1040.05n

* CHECK dout0_19 Vdout0_19ck103 = 0 time = 1040
.meas tran vdout0_19ck103 FIND v(dout0_19) AT=1040.05n

* CHECK dout0_20 Vdout0_20ck103 = 0 time = 1040
.meas tran vdout0_20ck103 FIND v(dout0_20) AT=1040.05n

* CHECK dout0_21 Vdout0_21ck103 = 1.8 time = 1040
.meas tran vdout0_21ck103 FIND v(dout0_21) AT=1040.05n

* CHECK dout0_22 Vdout0_22ck103 = 1.8 time = 1040
.meas tran vdout0_22ck103 FIND v(dout0_22) AT=1040.05n

* CHECK dout0_23 Vdout0_23ck103 = 0 time = 1040
.meas tran vdout0_23ck103 FIND v(dout0_23) AT=1040.05n

* CHECK dout0_24 Vdout0_24ck103 = 0 time = 1040
.meas tran vdout0_24ck103 FIND v(dout0_24) AT=1040.05n

* CHECK dout0_25 Vdout0_25ck103 = 1.8 time = 1040
.meas tran vdout0_25ck103 FIND v(dout0_25) AT=1040.05n

* CHECK dout0_26 Vdout0_26ck103 = 0 time = 1040
.meas tran vdout0_26ck103 FIND v(dout0_26) AT=1040.05n

* CHECK dout0_27 Vdout0_27ck103 = 1.8 time = 1040
.meas tran vdout0_27ck103 FIND v(dout0_27) AT=1040.05n

* CHECK dout0_28 Vdout0_28ck103 = 0 time = 1040
.meas tran vdout0_28ck103 FIND v(dout0_28) AT=1040.05n

* CHECK dout0_29 Vdout0_29ck103 = 1.8 time = 1040
.meas tran vdout0_29ck103 FIND v(dout0_29) AT=1040.05n

* CHECK dout0_30 Vdout0_30ck103 = 0 time = 1040
.meas tran vdout0_30ck103 FIND v(dout0_30) AT=1040.05n

* CHECK dout0_31 Vdout0_31ck103 = 0 time = 1040
.meas tran vdout0_31ck103 FIND v(dout0_31) AT=1040.05n

* CHECK dout0_32 Vdout0_32ck103 = 0 time = 1040
.meas tran vdout0_32ck103 FIND v(dout0_32) AT=1040.05n

* CHECK dout0_0 Vdout0_0ck107 = 1.8 time = 1080
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=1080.05n

* CHECK dout0_1 Vdout0_1ck107 = 1.8 time = 1080
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=1080.05n

* CHECK dout0_2 Vdout0_2ck107 = 0 time = 1080
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=1080.05n

* CHECK dout0_3 Vdout0_3ck107 = 0 time = 1080
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=1080.05n

* CHECK dout0_4 Vdout0_4ck107 = 0 time = 1080
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=1080.05n

* CHECK dout0_5 Vdout0_5ck107 = 0 time = 1080
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=1080.05n

* CHECK dout0_6 Vdout0_6ck107 = 1.8 time = 1080
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=1080.05n

* CHECK dout0_7 Vdout0_7ck107 = 0 time = 1080
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=1080.05n

* CHECK dout0_8 Vdout0_8ck107 = 0 time = 1080
.meas tran vdout0_8ck107 FIND v(dout0_8) AT=1080.05n

* CHECK dout0_9 Vdout0_9ck107 = 1.8 time = 1080
.meas tran vdout0_9ck107 FIND v(dout0_9) AT=1080.05n

* CHECK dout0_10 Vdout0_10ck107 = 0 time = 1080
.meas tran vdout0_10ck107 FIND v(dout0_10) AT=1080.05n

* CHECK dout0_11 Vdout0_11ck107 = 0 time = 1080
.meas tran vdout0_11ck107 FIND v(dout0_11) AT=1080.05n

* CHECK dout0_12 Vdout0_12ck107 = 0 time = 1080
.meas tran vdout0_12ck107 FIND v(dout0_12) AT=1080.05n

* CHECK dout0_13 Vdout0_13ck107 = 0 time = 1080
.meas tran vdout0_13ck107 FIND v(dout0_13) AT=1080.05n

* CHECK dout0_14 Vdout0_14ck107 = 0 time = 1080
.meas tran vdout0_14ck107 FIND v(dout0_14) AT=1080.05n

* CHECK dout0_15 Vdout0_15ck107 = 0 time = 1080
.meas tran vdout0_15ck107 FIND v(dout0_15) AT=1080.05n

* CHECK dout0_16 Vdout0_16ck107 = 1.8 time = 1080
.meas tran vdout0_16ck107 FIND v(dout0_16) AT=1080.05n

* CHECK dout0_17 Vdout0_17ck107 = 0 time = 1080
.meas tran vdout0_17ck107 FIND v(dout0_17) AT=1080.05n

* CHECK dout0_18 Vdout0_18ck107 = 0 time = 1080
.meas tran vdout0_18ck107 FIND v(dout0_18) AT=1080.05n

* CHECK dout0_19 Vdout0_19ck107 = 1.8 time = 1080
.meas tran vdout0_19ck107 FIND v(dout0_19) AT=1080.05n

* CHECK dout0_20 Vdout0_20ck107 = 1.8 time = 1080
.meas tran vdout0_20ck107 FIND v(dout0_20) AT=1080.05n

* CHECK dout0_21 Vdout0_21ck107 = 0 time = 1080
.meas tran vdout0_21ck107 FIND v(dout0_21) AT=1080.05n

* CHECK dout0_22 Vdout0_22ck107 = 1.8 time = 1080
.meas tran vdout0_22ck107 FIND v(dout0_22) AT=1080.05n

* CHECK dout0_23 Vdout0_23ck107 = 0 time = 1080
.meas tran vdout0_23ck107 FIND v(dout0_23) AT=1080.05n

* CHECK dout0_24 Vdout0_24ck107 = 0 time = 1080
.meas tran vdout0_24ck107 FIND v(dout0_24) AT=1080.05n

* CHECK dout0_25 Vdout0_25ck107 = 0 time = 1080
.meas tran vdout0_25ck107 FIND v(dout0_25) AT=1080.05n

* CHECK dout0_26 Vdout0_26ck107 = 0 time = 1080
.meas tran vdout0_26ck107 FIND v(dout0_26) AT=1080.05n

* CHECK dout0_27 Vdout0_27ck107 = 0 time = 1080
.meas tran vdout0_27ck107 FIND v(dout0_27) AT=1080.05n

* CHECK dout0_28 Vdout0_28ck107 = 0 time = 1080
.meas tran vdout0_28ck107 FIND v(dout0_28) AT=1080.05n

* CHECK dout0_29 Vdout0_29ck107 = 1.8 time = 1080
.meas tran vdout0_29ck107 FIND v(dout0_29) AT=1080.05n

* CHECK dout0_30 Vdout0_30ck107 = 0 time = 1080
.meas tran vdout0_30ck107 FIND v(dout0_30) AT=1080.05n

* CHECK dout0_31 Vdout0_31ck107 = 1.8 time = 1080
.meas tran vdout0_31ck107 FIND v(dout0_31) AT=1080.05n

* CHECK dout0_32 Vdout0_32ck107 = 0 time = 1080
.meas tran vdout0_32ck107 FIND v(dout0_32) AT=1080.05n

* CHECK dout0_0 Vdout0_0ck108 = 0 time = 1090
.meas tran vdout0_0ck108 FIND v(dout0_0) AT=1090.05n

* CHECK dout0_1 Vdout0_1ck108 = 0 time = 1090
.meas tran vdout0_1ck108 FIND v(dout0_1) AT=1090.05n

* CHECK dout0_2 Vdout0_2ck108 = 1.8 time = 1090
.meas tran vdout0_2ck108 FIND v(dout0_2) AT=1090.05n

* CHECK dout0_3 Vdout0_3ck108 = 1.8 time = 1090
.meas tran vdout0_3ck108 FIND v(dout0_3) AT=1090.05n

* CHECK dout0_4 Vdout0_4ck108 = 0 time = 1090
.meas tran vdout0_4ck108 FIND v(dout0_4) AT=1090.05n

* CHECK dout0_5 Vdout0_5ck108 = 1.8 time = 1090
.meas tran vdout0_5ck108 FIND v(dout0_5) AT=1090.05n

* CHECK dout0_6 Vdout0_6ck108 = 1.8 time = 1090
.meas tran vdout0_6ck108 FIND v(dout0_6) AT=1090.05n

* CHECK dout0_7 Vdout0_7ck108 = 0 time = 1090
.meas tran vdout0_7ck108 FIND v(dout0_7) AT=1090.05n

* CHECK dout0_8 Vdout0_8ck108 = 0 time = 1090
.meas tran vdout0_8ck108 FIND v(dout0_8) AT=1090.05n

* CHECK dout0_9 Vdout0_9ck108 = 0 time = 1090
.meas tran vdout0_9ck108 FIND v(dout0_9) AT=1090.05n

* CHECK dout0_10 Vdout0_10ck108 = 0 time = 1090
.meas tran vdout0_10ck108 FIND v(dout0_10) AT=1090.05n

* CHECK dout0_11 Vdout0_11ck108 = 0 time = 1090
.meas tran vdout0_11ck108 FIND v(dout0_11) AT=1090.05n

* CHECK dout0_12 Vdout0_12ck108 = 0 time = 1090
.meas tran vdout0_12ck108 FIND v(dout0_12) AT=1090.05n

* CHECK dout0_13 Vdout0_13ck108 = 0 time = 1090
.meas tran vdout0_13ck108 FIND v(dout0_13) AT=1090.05n

* CHECK dout0_14 Vdout0_14ck108 = 0 time = 1090
.meas tran vdout0_14ck108 FIND v(dout0_14) AT=1090.05n

* CHECK dout0_15 Vdout0_15ck108 = 1.8 time = 1090
.meas tran vdout0_15ck108 FIND v(dout0_15) AT=1090.05n

* CHECK dout0_16 Vdout0_16ck108 = 0 time = 1090
.meas tran vdout0_16ck108 FIND v(dout0_16) AT=1090.05n

* CHECK dout0_17 Vdout0_17ck108 = 0 time = 1090
.meas tran vdout0_17ck108 FIND v(dout0_17) AT=1090.05n

* CHECK dout0_18 Vdout0_18ck108 = 0 time = 1090
.meas tran vdout0_18ck108 FIND v(dout0_18) AT=1090.05n

* CHECK dout0_19 Vdout0_19ck108 = 0 time = 1090
.meas tran vdout0_19ck108 FIND v(dout0_19) AT=1090.05n

* CHECK dout0_20 Vdout0_20ck108 = 1.8 time = 1090
.meas tran vdout0_20ck108 FIND v(dout0_20) AT=1090.05n

* CHECK dout0_21 Vdout0_21ck108 = 1.8 time = 1090
.meas tran vdout0_21ck108 FIND v(dout0_21) AT=1090.05n

* CHECK dout0_22 Vdout0_22ck108 = 0 time = 1090
.meas tran vdout0_22ck108 FIND v(dout0_22) AT=1090.05n

* CHECK dout0_23 Vdout0_23ck108 = 0 time = 1090
.meas tran vdout0_23ck108 FIND v(dout0_23) AT=1090.05n

* CHECK dout0_24 Vdout0_24ck108 = 1.8 time = 1090
.meas tran vdout0_24ck108 FIND v(dout0_24) AT=1090.05n

* CHECK dout0_25 Vdout0_25ck108 = 0 time = 1090
.meas tran vdout0_25ck108 FIND v(dout0_25) AT=1090.05n

* CHECK dout0_26 Vdout0_26ck108 = 1.8 time = 1090
.meas tran vdout0_26ck108 FIND v(dout0_26) AT=1090.05n

* CHECK dout0_27 Vdout0_27ck108 = 0 time = 1090
.meas tran vdout0_27ck108 FIND v(dout0_27) AT=1090.05n

* CHECK dout0_28 Vdout0_28ck108 = 0 time = 1090
.meas tran vdout0_28ck108 FIND v(dout0_28) AT=1090.05n

* CHECK dout0_29 Vdout0_29ck108 = 0 time = 1090
.meas tran vdout0_29ck108 FIND v(dout0_29) AT=1090.05n

* CHECK dout0_30 Vdout0_30ck108 = 0 time = 1090
.meas tran vdout0_30ck108 FIND v(dout0_30) AT=1090.05n

* CHECK dout0_31 Vdout0_31ck108 = 1.8 time = 1090
.meas tran vdout0_31ck108 FIND v(dout0_31) AT=1090.05n

* CHECK dout0_32 Vdout0_32ck108 = 0 time = 1090
.meas tran vdout0_32ck108 FIND v(dout0_32) AT=1090.05n

* CHECK dout0_0 Vdout0_0ck109 = 0 time = 1100
.meas tran vdout0_0ck109 FIND v(dout0_0) AT=1100.05n

* CHECK dout0_1 Vdout0_1ck109 = 0 time = 1100
.meas tran vdout0_1ck109 FIND v(dout0_1) AT=1100.05n

* CHECK dout0_2 Vdout0_2ck109 = 1.8 time = 1100
.meas tran vdout0_2ck109 FIND v(dout0_2) AT=1100.05n

* CHECK dout0_3 Vdout0_3ck109 = 1.8 time = 1100
.meas tran vdout0_3ck109 FIND v(dout0_3) AT=1100.05n

* CHECK dout0_4 Vdout0_4ck109 = 0 time = 1100
.meas tran vdout0_4ck109 FIND v(dout0_4) AT=1100.05n

* CHECK dout0_5 Vdout0_5ck109 = 1.8 time = 1100
.meas tran vdout0_5ck109 FIND v(dout0_5) AT=1100.05n

* CHECK dout0_6 Vdout0_6ck109 = 1.8 time = 1100
.meas tran vdout0_6ck109 FIND v(dout0_6) AT=1100.05n

* CHECK dout0_7 Vdout0_7ck109 = 0 time = 1100
.meas tran vdout0_7ck109 FIND v(dout0_7) AT=1100.05n

* CHECK dout0_8 Vdout0_8ck109 = 0 time = 1100
.meas tran vdout0_8ck109 FIND v(dout0_8) AT=1100.05n

* CHECK dout0_9 Vdout0_9ck109 = 0 time = 1100
.meas tran vdout0_9ck109 FIND v(dout0_9) AT=1100.05n

* CHECK dout0_10 Vdout0_10ck109 = 0 time = 1100
.meas tran vdout0_10ck109 FIND v(dout0_10) AT=1100.05n

* CHECK dout0_11 Vdout0_11ck109 = 0 time = 1100
.meas tran vdout0_11ck109 FIND v(dout0_11) AT=1100.05n

* CHECK dout0_12 Vdout0_12ck109 = 0 time = 1100
.meas tran vdout0_12ck109 FIND v(dout0_12) AT=1100.05n

* CHECK dout0_13 Vdout0_13ck109 = 0 time = 1100
.meas tran vdout0_13ck109 FIND v(dout0_13) AT=1100.05n

* CHECK dout0_14 Vdout0_14ck109 = 0 time = 1100
.meas tran vdout0_14ck109 FIND v(dout0_14) AT=1100.05n

* CHECK dout0_15 Vdout0_15ck109 = 1.8 time = 1100
.meas tran vdout0_15ck109 FIND v(dout0_15) AT=1100.05n

* CHECK dout0_16 Vdout0_16ck109 = 0 time = 1100
.meas tran vdout0_16ck109 FIND v(dout0_16) AT=1100.05n

* CHECK dout0_17 Vdout0_17ck109 = 0 time = 1100
.meas tran vdout0_17ck109 FIND v(dout0_17) AT=1100.05n

* CHECK dout0_18 Vdout0_18ck109 = 0 time = 1100
.meas tran vdout0_18ck109 FIND v(dout0_18) AT=1100.05n

* CHECK dout0_19 Vdout0_19ck109 = 0 time = 1100
.meas tran vdout0_19ck109 FIND v(dout0_19) AT=1100.05n

* CHECK dout0_20 Vdout0_20ck109 = 1.8 time = 1100
.meas tran vdout0_20ck109 FIND v(dout0_20) AT=1100.05n

* CHECK dout0_21 Vdout0_21ck109 = 1.8 time = 1100
.meas tran vdout0_21ck109 FIND v(dout0_21) AT=1100.05n

* CHECK dout0_22 Vdout0_22ck109 = 0 time = 1100
.meas tran vdout0_22ck109 FIND v(dout0_22) AT=1100.05n

* CHECK dout0_23 Vdout0_23ck109 = 0 time = 1100
.meas tran vdout0_23ck109 FIND v(dout0_23) AT=1100.05n

* CHECK dout0_24 Vdout0_24ck109 = 1.8 time = 1100
.meas tran vdout0_24ck109 FIND v(dout0_24) AT=1100.05n

* CHECK dout0_25 Vdout0_25ck109 = 0 time = 1100
.meas tran vdout0_25ck109 FIND v(dout0_25) AT=1100.05n

* CHECK dout0_26 Vdout0_26ck109 = 1.8 time = 1100
.meas tran vdout0_26ck109 FIND v(dout0_26) AT=1100.05n

* CHECK dout0_27 Vdout0_27ck109 = 0 time = 1100
.meas tran vdout0_27ck109 FIND v(dout0_27) AT=1100.05n

* CHECK dout0_28 Vdout0_28ck109 = 0 time = 1100
.meas tran vdout0_28ck109 FIND v(dout0_28) AT=1100.05n

* CHECK dout0_29 Vdout0_29ck109 = 0 time = 1100
.meas tran vdout0_29ck109 FIND v(dout0_29) AT=1100.05n

* CHECK dout0_30 Vdout0_30ck109 = 0 time = 1100
.meas tran vdout0_30ck109 FIND v(dout0_30) AT=1100.05n

* CHECK dout0_31 Vdout0_31ck109 = 1.8 time = 1100
.meas tran vdout0_31ck109 FIND v(dout0_31) AT=1100.05n

* CHECK dout0_32 Vdout0_32ck109 = 0 time = 1100
.meas tran vdout0_32ck109 FIND v(dout0_32) AT=1100.05n

* CHECK dout0_0 Vdout0_0ck110 = 1.8 time = 1110
.meas tran vdout0_0ck110 FIND v(dout0_0) AT=1110.05n

* CHECK dout0_1 Vdout0_1ck110 = 1.8 time = 1110
.meas tran vdout0_1ck110 FIND v(dout0_1) AT=1110.05n

* CHECK dout0_2 Vdout0_2ck110 = 0 time = 1110
.meas tran vdout0_2ck110 FIND v(dout0_2) AT=1110.05n

* CHECK dout0_3 Vdout0_3ck110 = 0 time = 1110
.meas tran vdout0_3ck110 FIND v(dout0_3) AT=1110.05n

* CHECK dout0_4 Vdout0_4ck110 = 0 time = 1110
.meas tran vdout0_4ck110 FIND v(dout0_4) AT=1110.05n

* CHECK dout0_5 Vdout0_5ck110 = 0 time = 1110
.meas tran vdout0_5ck110 FIND v(dout0_5) AT=1110.05n

* CHECK dout0_6 Vdout0_6ck110 = 1.8 time = 1110
.meas tran vdout0_6ck110 FIND v(dout0_6) AT=1110.05n

* CHECK dout0_7 Vdout0_7ck110 = 0 time = 1110
.meas tran vdout0_7ck110 FIND v(dout0_7) AT=1110.05n

* CHECK dout0_8 Vdout0_8ck110 = 0 time = 1110
.meas tran vdout0_8ck110 FIND v(dout0_8) AT=1110.05n

* CHECK dout0_9 Vdout0_9ck110 = 1.8 time = 1110
.meas tran vdout0_9ck110 FIND v(dout0_9) AT=1110.05n

* CHECK dout0_10 Vdout0_10ck110 = 0 time = 1110
.meas tran vdout0_10ck110 FIND v(dout0_10) AT=1110.05n

* CHECK dout0_11 Vdout0_11ck110 = 0 time = 1110
.meas tran vdout0_11ck110 FIND v(dout0_11) AT=1110.05n

* CHECK dout0_12 Vdout0_12ck110 = 0 time = 1110
.meas tran vdout0_12ck110 FIND v(dout0_12) AT=1110.05n

* CHECK dout0_13 Vdout0_13ck110 = 0 time = 1110
.meas tran vdout0_13ck110 FIND v(dout0_13) AT=1110.05n

* CHECK dout0_14 Vdout0_14ck110 = 0 time = 1110
.meas tran vdout0_14ck110 FIND v(dout0_14) AT=1110.05n

* CHECK dout0_15 Vdout0_15ck110 = 0 time = 1110
.meas tran vdout0_15ck110 FIND v(dout0_15) AT=1110.05n

* CHECK dout0_16 Vdout0_16ck110 = 1.8 time = 1110
.meas tran vdout0_16ck110 FIND v(dout0_16) AT=1110.05n

* CHECK dout0_17 Vdout0_17ck110 = 0 time = 1110
.meas tran vdout0_17ck110 FIND v(dout0_17) AT=1110.05n

* CHECK dout0_18 Vdout0_18ck110 = 0 time = 1110
.meas tran vdout0_18ck110 FIND v(dout0_18) AT=1110.05n

* CHECK dout0_19 Vdout0_19ck110 = 1.8 time = 1110
.meas tran vdout0_19ck110 FIND v(dout0_19) AT=1110.05n

* CHECK dout0_20 Vdout0_20ck110 = 1.8 time = 1110
.meas tran vdout0_20ck110 FIND v(dout0_20) AT=1110.05n

* CHECK dout0_21 Vdout0_21ck110 = 0 time = 1110
.meas tran vdout0_21ck110 FIND v(dout0_21) AT=1110.05n

* CHECK dout0_22 Vdout0_22ck110 = 1.8 time = 1110
.meas tran vdout0_22ck110 FIND v(dout0_22) AT=1110.05n

* CHECK dout0_23 Vdout0_23ck110 = 0 time = 1110
.meas tran vdout0_23ck110 FIND v(dout0_23) AT=1110.05n

* CHECK dout0_24 Vdout0_24ck110 = 0 time = 1110
.meas tran vdout0_24ck110 FIND v(dout0_24) AT=1110.05n

* CHECK dout0_25 Vdout0_25ck110 = 0 time = 1110
.meas tran vdout0_25ck110 FIND v(dout0_25) AT=1110.05n

* CHECK dout0_26 Vdout0_26ck110 = 0 time = 1110
.meas tran vdout0_26ck110 FIND v(dout0_26) AT=1110.05n

* CHECK dout0_27 Vdout0_27ck110 = 0 time = 1110
.meas tran vdout0_27ck110 FIND v(dout0_27) AT=1110.05n

* CHECK dout0_28 Vdout0_28ck110 = 0 time = 1110
.meas tran vdout0_28ck110 FIND v(dout0_28) AT=1110.05n

* CHECK dout0_29 Vdout0_29ck110 = 1.8 time = 1110
.meas tran vdout0_29ck110 FIND v(dout0_29) AT=1110.05n

* CHECK dout0_30 Vdout0_30ck110 = 0 time = 1110
.meas tran vdout0_30ck110 FIND v(dout0_30) AT=1110.05n

* CHECK dout0_31 Vdout0_31ck110 = 1.8 time = 1110
.meas tran vdout0_31ck110 FIND v(dout0_31) AT=1110.05n

* CHECK dout0_32 Vdout0_32ck110 = 0 time = 1110
.meas tran vdout0_32ck110 FIND v(dout0_32) AT=1110.05n

* CHECK dout0_0 Vdout0_0ck111 = 0 time = 1120
.meas tran vdout0_0ck111 FIND v(dout0_0) AT=1120.05n

* CHECK dout0_1 Vdout0_1ck111 = 0 time = 1120
.meas tran vdout0_1ck111 FIND v(dout0_1) AT=1120.05n

* CHECK dout0_2 Vdout0_2ck111 = 1.8 time = 1120
.meas tran vdout0_2ck111 FIND v(dout0_2) AT=1120.05n

* CHECK dout0_3 Vdout0_3ck111 = 1.8 time = 1120
.meas tran vdout0_3ck111 FIND v(dout0_3) AT=1120.05n

* CHECK dout0_4 Vdout0_4ck111 = 0 time = 1120
.meas tran vdout0_4ck111 FIND v(dout0_4) AT=1120.05n

* CHECK dout0_5 Vdout0_5ck111 = 1.8 time = 1120
.meas tran vdout0_5ck111 FIND v(dout0_5) AT=1120.05n

* CHECK dout0_6 Vdout0_6ck111 = 1.8 time = 1120
.meas tran vdout0_6ck111 FIND v(dout0_6) AT=1120.05n

* CHECK dout0_7 Vdout0_7ck111 = 0 time = 1120
.meas tran vdout0_7ck111 FIND v(dout0_7) AT=1120.05n

* CHECK dout0_8 Vdout0_8ck111 = 0 time = 1120
.meas tran vdout0_8ck111 FIND v(dout0_8) AT=1120.05n

* CHECK dout0_9 Vdout0_9ck111 = 0 time = 1120
.meas tran vdout0_9ck111 FIND v(dout0_9) AT=1120.05n

* CHECK dout0_10 Vdout0_10ck111 = 0 time = 1120
.meas tran vdout0_10ck111 FIND v(dout0_10) AT=1120.05n

* CHECK dout0_11 Vdout0_11ck111 = 0 time = 1120
.meas tran vdout0_11ck111 FIND v(dout0_11) AT=1120.05n

* CHECK dout0_12 Vdout0_12ck111 = 0 time = 1120
.meas tran vdout0_12ck111 FIND v(dout0_12) AT=1120.05n

* CHECK dout0_13 Vdout0_13ck111 = 0 time = 1120
.meas tran vdout0_13ck111 FIND v(dout0_13) AT=1120.05n

* CHECK dout0_14 Vdout0_14ck111 = 0 time = 1120
.meas tran vdout0_14ck111 FIND v(dout0_14) AT=1120.05n

* CHECK dout0_15 Vdout0_15ck111 = 1.8 time = 1120
.meas tran vdout0_15ck111 FIND v(dout0_15) AT=1120.05n

* CHECK dout0_16 Vdout0_16ck111 = 0 time = 1120
.meas tran vdout0_16ck111 FIND v(dout0_16) AT=1120.05n

* CHECK dout0_17 Vdout0_17ck111 = 0 time = 1120
.meas tran vdout0_17ck111 FIND v(dout0_17) AT=1120.05n

* CHECK dout0_18 Vdout0_18ck111 = 0 time = 1120
.meas tran vdout0_18ck111 FIND v(dout0_18) AT=1120.05n

* CHECK dout0_19 Vdout0_19ck111 = 0 time = 1120
.meas tran vdout0_19ck111 FIND v(dout0_19) AT=1120.05n

* CHECK dout0_20 Vdout0_20ck111 = 1.8 time = 1120
.meas tran vdout0_20ck111 FIND v(dout0_20) AT=1120.05n

* CHECK dout0_21 Vdout0_21ck111 = 1.8 time = 1120
.meas tran vdout0_21ck111 FIND v(dout0_21) AT=1120.05n

* CHECK dout0_22 Vdout0_22ck111 = 0 time = 1120
.meas tran vdout0_22ck111 FIND v(dout0_22) AT=1120.05n

* CHECK dout0_23 Vdout0_23ck111 = 0 time = 1120
.meas tran vdout0_23ck111 FIND v(dout0_23) AT=1120.05n

* CHECK dout0_24 Vdout0_24ck111 = 1.8 time = 1120
.meas tran vdout0_24ck111 FIND v(dout0_24) AT=1120.05n

* CHECK dout0_25 Vdout0_25ck111 = 0 time = 1120
.meas tran vdout0_25ck111 FIND v(dout0_25) AT=1120.05n

* CHECK dout0_26 Vdout0_26ck111 = 1.8 time = 1120
.meas tran vdout0_26ck111 FIND v(dout0_26) AT=1120.05n

* CHECK dout0_27 Vdout0_27ck111 = 0 time = 1120
.meas tran vdout0_27ck111 FIND v(dout0_27) AT=1120.05n

* CHECK dout0_28 Vdout0_28ck111 = 0 time = 1120
.meas tran vdout0_28ck111 FIND v(dout0_28) AT=1120.05n

* CHECK dout0_29 Vdout0_29ck111 = 0 time = 1120
.meas tran vdout0_29ck111 FIND v(dout0_29) AT=1120.05n

* CHECK dout0_30 Vdout0_30ck111 = 0 time = 1120
.meas tran vdout0_30ck111 FIND v(dout0_30) AT=1120.05n

* CHECK dout0_31 Vdout0_31ck111 = 1.8 time = 1120
.meas tran vdout0_31ck111 FIND v(dout0_31) AT=1120.05n

* CHECK dout0_32 Vdout0_32ck111 = 0 time = 1120
.meas tran vdout0_32ck111 FIND v(dout0_32) AT=1120.05n

* CHECK dout0_0 Vdout0_0ck112 = 0 time = 1130
.meas tran vdout0_0ck112 FIND v(dout0_0) AT=1130.05n

* CHECK dout0_1 Vdout0_1ck112 = 0 time = 1130
.meas tran vdout0_1ck112 FIND v(dout0_1) AT=1130.05n

* CHECK dout0_2 Vdout0_2ck112 = 1.8 time = 1130
.meas tran vdout0_2ck112 FIND v(dout0_2) AT=1130.05n

* CHECK dout0_3 Vdout0_3ck112 = 1.8 time = 1130
.meas tran vdout0_3ck112 FIND v(dout0_3) AT=1130.05n

* CHECK dout0_4 Vdout0_4ck112 = 0 time = 1130
.meas tran vdout0_4ck112 FIND v(dout0_4) AT=1130.05n

* CHECK dout0_5 Vdout0_5ck112 = 1.8 time = 1130
.meas tran vdout0_5ck112 FIND v(dout0_5) AT=1130.05n

* CHECK dout0_6 Vdout0_6ck112 = 1.8 time = 1130
.meas tran vdout0_6ck112 FIND v(dout0_6) AT=1130.05n

* CHECK dout0_7 Vdout0_7ck112 = 0 time = 1130
.meas tran vdout0_7ck112 FIND v(dout0_7) AT=1130.05n

* CHECK dout0_8 Vdout0_8ck112 = 0 time = 1130
.meas tran vdout0_8ck112 FIND v(dout0_8) AT=1130.05n

* CHECK dout0_9 Vdout0_9ck112 = 0 time = 1130
.meas tran vdout0_9ck112 FIND v(dout0_9) AT=1130.05n

* CHECK dout0_10 Vdout0_10ck112 = 0 time = 1130
.meas tran vdout0_10ck112 FIND v(dout0_10) AT=1130.05n

* CHECK dout0_11 Vdout0_11ck112 = 0 time = 1130
.meas tran vdout0_11ck112 FIND v(dout0_11) AT=1130.05n

* CHECK dout0_12 Vdout0_12ck112 = 0 time = 1130
.meas tran vdout0_12ck112 FIND v(dout0_12) AT=1130.05n

* CHECK dout0_13 Vdout0_13ck112 = 0 time = 1130
.meas tran vdout0_13ck112 FIND v(dout0_13) AT=1130.05n

* CHECK dout0_14 Vdout0_14ck112 = 0 time = 1130
.meas tran vdout0_14ck112 FIND v(dout0_14) AT=1130.05n

* CHECK dout0_15 Vdout0_15ck112 = 1.8 time = 1130
.meas tran vdout0_15ck112 FIND v(dout0_15) AT=1130.05n

* CHECK dout0_16 Vdout0_16ck112 = 0 time = 1130
.meas tran vdout0_16ck112 FIND v(dout0_16) AT=1130.05n

* CHECK dout0_17 Vdout0_17ck112 = 0 time = 1130
.meas tran vdout0_17ck112 FIND v(dout0_17) AT=1130.05n

* CHECK dout0_18 Vdout0_18ck112 = 0 time = 1130
.meas tran vdout0_18ck112 FIND v(dout0_18) AT=1130.05n

* CHECK dout0_19 Vdout0_19ck112 = 0 time = 1130
.meas tran vdout0_19ck112 FIND v(dout0_19) AT=1130.05n

* CHECK dout0_20 Vdout0_20ck112 = 1.8 time = 1130
.meas tran vdout0_20ck112 FIND v(dout0_20) AT=1130.05n

* CHECK dout0_21 Vdout0_21ck112 = 1.8 time = 1130
.meas tran vdout0_21ck112 FIND v(dout0_21) AT=1130.05n

* CHECK dout0_22 Vdout0_22ck112 = 0 time = 1130
.meas tran vdout0_22ck112 FIND v(dout0_22) AT=1130.05n

* CHECK dout0_23 Vdout0_23ck112 = 0 time = 1130
.meas tran vdout0_23ck112 FIND v(dout0_23) AT=1130.05n

* CHECK dout0_24 Vdout0_24ck112 = 1.8 time = 1130
.meas tran vdout0_24ck112 FIND v(dout0_24) AT=1130.05n

* CHECK dout0_25 Vdout0_25ck112 = 0 time = 1130
.meas tran vdout0_25ck112 FIND v(dout0_25) AT=1130.05n

* CHECK dout0_26 Vdout0_26ck112 = 1.8 time = 1130
.meas tran vdout0_26ck112 FIND v(dout0_26) AT=1130.05n

* CHECK dout0_27 Vdout0_27ck112 = 0 time = 1130
.meas tran vdout0_27ck112 FIND v(dout0_27) AT=1130.05n

* CHECK dout0_28 Vdout0_28ck112 = 0 time = 1130
.meas tran vdout0_28ck112 FIND v(dout0_28) AT=1130.05n

* CHECK dout0_29 Vdout0_29ck112 = 0 time = 1130
.meas tran vdout0_29ck112 FIND v(dout0_29) AT=1130.05n

* CHECK dout0_30 Vdout0_30ck112 = 0 time = 1130
.meas tran vdout0_30ck112 FIND v(dout0_30) AT=1130.05n

* CHECK dout0_31 Vdout0_31ck112 = 1.8 time = 1130
.meas tran vdout0_31ck112 FIND v(dout0_31) AT=1130.05n

* CHECK dout0_32 Vdout0_32ck112 = 0 time = 1130
.meas tran vdout0_32ck112 FIND v(dout0_32) AT=1130.05n

* CHECK dout0_0 Vdout0_0ck113 = 1.8 time = 1140
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=1140.05n

* CHECK dout0_1 Vdout0_1ck113 = 1.8 time = 1140
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=1140.05n

* CHECK dout0_2 Vdout0_2ck113 = 0 time = 1140
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=1140.05n

* CHECK dout0_3 Vdout0_3ck113 = 0 time = 1140
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=1140.05n

* CHECK dout0_4 Vdout0_4ck113 = 0 time = 1140
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=1140.05n

* CHECK dout0_5 Vdout0_5ck113 = 0 time = 1140
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=1140.05n

* CHECK dout0_6 Vdout0_6ck113 = 1.8 time = 1140
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=1140.05n

* CHECK dout0_7 Vdout0_7ck113 = 0 time = 1140
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=1140.05n

* CHECK dout0_8 Vdout0_8ck113 = 0 time = 1140
.meas tran vdout0_8ck113 FIND v(dout0_8) AT=1140.05n

* CHECK dout0_9 Vdout0_9ck113 = 1.8 time = 1140
.meas tran vdout0_9ck113 FIND v(dout0_9) AT=1140.05n

* CHECK dout0_10 Vdout0_10ck113 = 0 time = 1140
.meas tran vdout0_10ck113 FIND v(dout0_10) AT=1140.05n

* CHECK dout0_11 Vdout0_11ck113 = 0 time = 1140
.meas tran vdout0_11ck113 FIND v(dout0_11) AT=1140.05n

* CHECK dout0_12 Vdout0_12ck113 = 0 time = 1140
.meas tran vdout0_12ck113 FIND v(dout0_12) AT=1140.05n

* CHECK dout0_13 Vdout0_13ck113 = 0 time = 1140
.meas tran vdout0_13ck113 FIND v(dout0_13) AT=1140.05n

* CHECK dout0_14 Vdout0_14ck113 = 0 time = 1140
.meas tran vdout0_14ck113 FIND v(dout0_14) AT=1140.05n

* CHECK dout0_15 Vdout0_15ck113 = 0 time = 1140
.meas tran vdout0_15ck113 FIND v(dout0_15) AT=1140.05n

* CHECK dout0_16 Vdout0_16ck113 = 1.8 time = 1140
.meas tran vdout0_16ck113 FIND v(dout0_16) AT=1140.05n

* CHECK dout0_17 Vdout0_17ck113 = 0 time = 1140
.meas tran vdout0_17ck113 FIND v(dout0_17) AT=1140.05n

* CHECK dout0_18 Vdout0_18ck113 = 0 time = 1140
.meas tran vdout0_18ck113 FIND v(dout0_18) AT=1140.05n

* CHECK dout0_19 Vdout0_19ck113 = 1.8 time = 1140
.meas tran vdout0_19ck113 FIND v(dout0_19) AT=1140.05n

* CHECK dout0_20 Vdout0_20ck113 = 1.8 time = 1140
.meas tran vdout0_20ck113 FIND v(dout0_20) AT=1140.05n

* CHECK dout0_21 Vdout0_21ck113 = 0 time = 1140
.meas tran vdout0_21ck113 FIND v(dout0_21) AT=1140.05n

* CHECK dout0_22 Vdout0_22ck113 = 1.8 time = 1140
.meas tran vdout0_22ck113 FIND v(dout0_22) AT=1140.05n

* CHECK dout0_23 Vdout0_23ck113 = 0 time = 1140
.meas tran vdout0_23ck113 FIND v(dout0_23) AT=1140.05n

* CHECK dout0_24 Vdout0_24ck113 = 0 time = 1140
.meas tran vdout0_24ck113 FIND v(dout0_24) AT=1140.05n

* CHECK dout0_25 Vdout0_25ck113 = 0 time = 1140
.meas tran vdout0_25ck113 FIND v(dout0_25) AT=1140.05n

* CHECK dout0_26 Vdout0_26ck113 = 0 time = 1140
.meas tran vdout0_26ck113 FIND v(dout0_26) AT=1140.05n

* CHECK dout0_27 Vdout0_27ck113 = 0 time = 1140
.meas tran vdout0_27ck113 FIND v(dout0_27) AT=1140.05n

* CHECK dout0_28 Vdout0_28ck113 = 0 time = 1140
.meas tran vdout0_28ck113 FIND v(dout0_28) AT=1140.05n

* CHECK dout0_29 Vdout0_29ck113 = 1.8 time = 1140
.meas tran vdout0_29ck113 FIND v(dout0_29) AT=1140.05n

* CHECK dout0_30 Vdout0_30ck113 = 0 time = 1140
.meas tran vdout0_30ck113 FIND v(dout0_30) AT=1140.05n

* CHECK dout0_31 Vdout0_31ck113 = 1.8 time = 1140
.meas tran vdout0_31ck113 FIND v(dout0_31) AT=1140.05n

* CHECK dout0_32 Vdout0_32ck113 = 0 time = 1140
.meas tran vdout0_32ck113 FIND v(dout0_32) AT=1140.05n

* CHECK dout0_0 Vdout0_0ck114 = 0 time = 1150
.meas tran vdout0_0ck114 FIND v(dout0_0) AT=1150.05n

* CHECK dout0_1 Vdout0_1ck114 = 0 time = 1150
.meas tran vdout0_1ck114 FIND v(dout0_1) AT=1150.05n

* CHECK dout0_2 Vdout0_2ck114 = 1.8 time = 1150
.meas tran vdout0_2ck114 FIND v(dout0_2) AT=1150.05n

* CHECK dout0_3 Vdout0_3ck114 = 1.8 time = 1150
.meas tran vdout0_3ck114 FIND v(dout0_3) AT=1150.05n

* CHECK dout0_4 Vdout0_4ck114 = 0 time = 1150
.meas tran vdout0_4ck114 FIND v(dout0_4) AT=1150.05n

* CHECK dout0_5 Vdout0_5ck114 = 1.8 time = 1150
.meas tran vdout0_5ck114 FIND v(dout0_5) AT=1150.05n

* CHECK dout0_6 Vdout0_6ck114 = 1.8 time = 1150
.meas tran vdout0_6ck114 FIND v(dout0_6) AT=1150.05n

* CHECK dout0_7 Vdout0_7ck114 = 0 time = 1150
.meas tran vdout0_7ck114 FIND v(dout0_7) AT=1150.05n

* CHECK dout0_8 Vdout0_8ck114 = 0 time = 1150
.meas tran vdout0_8ck114 FIND v(dout0_8) AT=1150.05n

* CHECK dout0_9 Vdout0_9ck114 = 0 time = 1150
.meas tran vdout0_9ck114 FIND v(dout0_9) AT=1150.05n

* CHECK dout0_10 Vdout0_10ck114 = 0 time = 1150
.meas tran vdout0_10ck114 FIND v(dout0_10) AT=1150.05n

* CHECK dout0_11 Vdout0_11ck114 = 0 time = 1150
.meas tran vdout0_11ck114 FIND v(dout0_11) AT=1150.05n

* CHECK dout0_12 Vdout0_12ck114 = 0 time = 1150
.meas tran vdout0_12ck114 FIND v(dout0_12) AT=1150.05n

* CHECK dout0_13 Vdout0_13ck114 = 0 time = 1150
.meas tran vdout0_13ck114 FIND v(dout0_13) AT=1150.05n

* CHECK dout0_14 Vdout0_14ck114 = 0 time = 1150
.meas tran vdout0_14ck114 FIND v(dout0_14) AT=1150.05n

* CHECK dout0_15 Vdout0_15ck114 = 1.8 time = 1150
.meas tran vdout0_15ck114 FIND v(dout0_15) AT=1150.05n

* CHECK dout0_16 Vdout0_16ck114 = 0 time = 1150
.meas tran vdout0_16ck114 FIND v(dout0_16) AT=1150.05n

* CHECK dout0_17 Vdout0_17ck114 = 0 time = 1150
.meas tran vdout0_17ck114 FIND v(dout0_17) AT=1150.05n

* CHECK dout0_18 Vdout0_18ck114 = 0 time = 1150
.meas tran vdout0_18ck114 FIND v(dout0_18) AT=1150.05n

* CHECK dout0_19 Vdout0_19ck114 = 0 time = 1150
.meas tran vdout0_19ck114 FIND v(dout0_19) AT=1150.05n

* CHECK dout0_20 Vdout0_20ck114 = 1.8 time = 1150
.meas tran vdout0_20ck114 FIND v(dout0_20) AT=1150.05n

* CHECK dout0_21 Vdout0_21ck114 = 1.8 time = 1150
.meas tran vdout0_21ck114 FIND v(dout0_21) AT=1150.05n

* CHECK dout0_22 Vdout0_22ck114 = 0 time = 1150
.meas tran vdout0_22ck114 FIND v(dout0_22) AT=1150.05n

* CHECK dout0_23 Vdout0_23ck114 = 0 time = 1150
.meas tran vdout0_23ck114 FIND v(dout0_23) AT=1150.05n

* CHECK dout0_24 Vdout0_24ck114 = 1.8 time = 1150
.meas tran vdout0_24ck114 FIND v(dout0_24) AT=1150.05n

* CHECK dout0_25 Vdout0_25ck114 = 0 time = 1150
.meas tran vdout0_25ck114 FIND v(dout0_25) AT=1150.05n

* CHECK dout0_26 Vdout0_26ck114 = 1.8 time = 1150
.meas tran vdout0_26ck114 FIND v(dout0_26) AT=1150.05n

* CHECK dout0_27 Vdout0_27ck114 = 0 time = 1150
.meas tran vdout0_27ck114 FIND v(dout0_27) AT=1150.05n

* CHECK dout0_28 Vdout0_28ck114 = 0 time = 1150
.meas tran vdout0_28ck114 FIND v(dout0_28) AT=1150.05n

* CHECK dout0_29 Vdout0_29ck114 = 0 time = 1150
.meas tran vdout0_29ck114 FIND v(dout0_29) AT=1150.05n

* CHECK dout0_30 Vdout0_30ck114 = 0 time = 1150
.meas tran vdout0_30ck114 FIND v(dout0_30) AT=1150.05n

* CHECK dout0_31 Vdout0_31ck114 = 1.8 time = 1150
.meas tran vdout0_31ck114 FIND v(dout0_31) AT=1150.05n

* CHECK dout0_32 Vdout0_32ck114 = 0 time = 1150
.meas tran vdout0_32ck114 FIND v(dout0_32) AT=1150.05n

* CHECK dout0_0 Vdout0_0ck115 = 0 time = 1160
.meas tran vdout0_0ck115 FIND v(dout0_0) AT=1160.05n

* CHECK dout0_1 Vdout0_1ck115 = 0 time = 1160
.meas tran vdout0_1ck115 FIND v(dout0_1) AT=1160.05n

* CHECK dout0_2 Vdout0_2ck115 = 1.8 time = 1160
.meas tran vdout0_2ck115 FIND v(dout0_2) AT=1160.05n

* CHECK dout0_3 Vdout0_3ck115 = 1.8 time = 1160
.meas tran vdout0_3ck115 FIND v(dout0_3) AT=1160.05n

* CHECK dout0_4 Vdout0_4ck115 = 0 time = 1160
.meas tran vdout0_4ck115 FIND v(dout0_4) AT=1160.05n

* CHECK dout0_5 Vdout0_5ck115 = 1.8 time = 1160
.meas tran vdout0_5ck115 FIND v(dout0_5) AT=1160.05n

* CHECK dout0_6 Vdout0_6ck115 = 1.8 time = 1160
.meas tran vdout0_6ck115 FIND v(dout0_6) AT=1160.05n

* CHECK dout0_7 Vdout0_7ck115 = 0 time = 1160
.meas tran vdout0_7ck115 FIND v(dout0_7) AT=1160.05n

* CHECK dout0_8 Vdout0_8ck115 = 0 time = 1160
.meas tran vdout0_8ck115 FIND v(dout0_8) AT=1160.05n

* CHECK dout0_9 Vdout0_9ck115 = 0 time = 1160
.meas tran vdout0_9ck115 FIND v(dout0_9) AT=1160.05n

* CHECK dout0_10 Vdout0_10ck115 = 0 time = 1160
.meas tran vdout0_10ck115 FIND v(dout0_10) AT=1160.05n

* CHECK dout0_11 Vdout0_11ck115 = 0 time = 1160
.meas tran vdout0_11ck115 FIND v(dout0_11) AT=1160.05n

* CHECK dout0_12 Vdout0_12ck115 = 0 time = 1160
.meas tran vdout0_12ck115 FIND v(dout0_12) AT=1160.05n

* CHECK dout0_13 Vdout0_13ck115 = 0 time = 1160
.meas tran vdout0_13ck115 FIND v(dout0_13) AT=1160.05n

* CHECK dout0_14 Vdout0_14ck115 = 0 time = 1160
.meas tran vdout0_14ck115 FIND v(dout0_14) AT=1160.05n

* CHECK dout0_15 Vdout0_15ck115 = 1.8 time = 1160
.meas tran vdout0_15ck115 FIND v(dout0_15) AT=1160.05n

* CHECK dout0_16 Vdout0_16ck115 = 0 time = 1160
.meas tran vdout0_16ck115 FIND v(dout0_16) AT=1160.05n

* CHECK dout0_17 Vdout0_17ck115 = 0 time = 1160
.meas tran vdout0_17ck115 FIND v(dout0_17) AT=1160.05n

* CHECK dout0_18 Vdout0_18ck115 = 0 time = 1160
.meas tran vdout0_18ck115 FIND v(dout0_18) AT=1160.05n

* CHECK dout0_19 Vdout0_19ck115 = 0 time = 1160
.meas tran vdout0_19ck115 FIND v(dout0_19) AT=1160.05n

* CHECK dout0_20 Vdout0_20ck115 = 1.8 time = 1160
.meas tran vdout0_20ck115 FIND v(dout0_20) AT=1160.05n

* CHECK dout0_21 Vdout0_21ck115 = 1.8 time = 1160
.meas tran vdout0_21ck115 FIND v(dout0_21) AT=1160.05n

* CHECK dout0_22 Vdout0_22ck115 = 0 time = 1160
.meas tran vdout0_22ck115 FIND v(dout0_22) AT=1160.05n

* CHECK dout0_23 Vdout0_23ck115 = 0 time = 1160
.meas tran vdout0_23ck115 FIND v(dout0_23) AT=1160.05n

* CHECK dout0_24 Vdout0_24ck115 = 1.8 time = 1160
.meas tran vdout0_24ck115 FIND v(dout0_24) AT=1160.05n

* CHECK dout0_25 Vdout0_25ck115 = 0 time = 1160
.meas tran vdout0_25ck115 FIND v(dout0_25) AT=1160.05n

* CHECK dout0_26 Vdout0_26ck115 = 1.8 time = 1160
.meas tran vdout0_26ck115 FIND v(dout0_26) AT=1160.05n

* CHECK dout0_27 Vdout0_27ck115 = 0 time = 1160
.meas tran vdout0_27ck115 FIND v(dout0_27) AT=1160.05n

* CHECK dout0_28 Vdout0_28ck115 = 0 time = 1160
.meas tran vdout0_28ck115 FIND v(dout0_28) AT=1160.05n

* CHECK dout0_29 Vdout0_29ck115 = 0 time = 1160
.meas tran vdout0_29ck115 FIND v(dout0_29) AT=1160.05n

* CHECK dout0_30 Vdout0_30ck115 = 0 time = 1160
.meas tran vdout0_30ck115 FIND v(dout0_30) AT=1160.05n

* CHECK dout0_31 Vdout0_31ck115 = 1.8 time = 1160
.meas tran vdout0_31ck115 FIND v(dout0_31) AT=1160.05n

* CHECK dout0_32 Vdout0_32ck115 = 0 time = 1160
.meas tran vdout0_32ck115 FIND v(dout0_32) AT=1160.05n

* CHECK dout0_0 Vdout0_0ck116 = 0 time = 1170
.meas tran vdout0_0ck116 FIND v(dout0_0) AT=1170.05n

* CHECK dout0_1 Vdout0_1ck116 = 0 time = 1170
.meas tran vdout0_1ck116 FIND v(dout0_1) AT=1170.05n

* CHECK dout0_2 Vdout0_2ck116 = 1.8 time = 1170
.meas tran vdout0_2ck116 FIND v(dout0_2) AT=1170.05n

* CHECK dout0_3 Vdout0_3ck116 = 1.8 time = 1170
.meas tran vdout0_3ck116 FIND v(dout0_3) AT=1170.05n

* CHECK dout0_4 Vdout0_4ck116 = 0 time = 1170
.meas tran vdout0_4ck116 FIND v(dout0_4) AT=1170.05n

* CHECK dout0_5 Vdout0_5ck116 = 1.8 time = 1170
.meas tran vdout0_5ck116 FIND v(dout0_5) AT=1170.05n

* CHECK dout0_6 Vdout0_6ck116 = 1.8 time = 1170
.meas tran vdout0_6ck116 FIND v(dout0_6) AT=1170.05n

* CHECK dout0_7 Vdout0_7ck116 = 0 time = 1170
.meas tran vdout0_7ck116 FIND v(dout0_7) AT=1170.05n

* CHECK dout0_8 Vdout0_8ck116 = 0 time = 1170
.meas tran vdout0_8ck116 FIND v(dout0_8) AT=1170.05n

* CHECK dout0_9 Vdout0_9ck116 = 0 time = 1170
.meas tran vdout0_9ck116 FIND v(dout0_9) AT=1170.05n

* CHECK dout0_10 Vdout0_10ck116 = 0 time = 1170
.meas tran vdout0_10ck116 FIND v(dout0_10) AT=1170.05n

* CHECK dout0_11 Vdout0_11ck116 = 0 time = 1170
.meas tran vdout0_11ck116 FIND v(dout0_11) AT=1170.05n

* CHECK dout0_12 Vdout0_12ck116 = 0 time = 1170
.meas tran vdout0_12ck116 FIND v(dout0_12) AT=1170.05n

* CHECK dout0_13 Vdout0_13ck116 = 0 time = 1170
.meas tran vdout0_13ck116 FIND v(dout0_13) AT=1170.05n

* CHECK dout0_14 Vdout0_14ck116 = 0 time = 1170
.meas tran vdout0_14ck116 FIND v(dout0_14) AT=1170.05n

* CHECK dout0_15 Vdout0_15ck116 = 1.8 time = 1170
.meas tran vdout0_15ck116 FIND v(dout0_15) AT=1170.05n

* CHECK dout0_16 Vdout0_16ck116 = 0 time = 1170
.meas tran vdout0_16ck116 FIND v(dout0_16) AT=1170.05n

* CHECK dout0_17 Vdout0_17ck116 = 0 time = 1170
.meas tran vdout0_17ck116 FIND v(dout0_17) AT=1170.05n

* CHECK dout0_18 Vdout0_18ck116 = 0 time = 1170
.meas tran vdout0_18ck116 FIND v(dout0_18) AT=1170.05n

* CHECK dout0_19 Vdout0_19ck116 = 0 time = 1170
.meas tran vdout0_19ck116 FIND v(dout0_19) AT=1170.05n

* CHECK dout0_20 Vdout0_20ck116 = 1.8 time = 1170
.meas tran vdout0_20ck116 FIND v(dout0_20) AT=1170.05n

* CHECK dout0_21 Vdout0_21ck116 = 1.8 time = 1170
.meas tran vdout0_21ck116 FIND v(dout0_21) AT=1170.05n

* CHECK dout0_22 Vdout0_22ck116 = 0 time = 1170
.meas tran vdout0_22ck116 FIND v(dout0_22) AT=1170.05n

* CHECK dout0_23 Vdout0_23ck116 = 0 time = 1170
.meas tran vdout0_23ck116 FIND v(dout0_23) AT=1170.05n

* CHECK dout0_24 Vdout0_24ck116 = 1.8 time = 1170
.meas tran vdout0_24ck116 FIND v(dout0_24) AT=1170.05n

* CHECK dout0_25 Vdout0_25ck116 = 0 time = 1170
.meas tran vdout0_25ck116 FIND v(dout0_25) AT=1170.05n

* CHECK dout0_26 Vdout0_26ck116 = 1.8 time = 1170
.meas tran vdout0_26ck116 FIND v(dout0_26) AT=1170.05n

* CHECK dout0_27 Vdout0_27ck116 = 0 time = 1170
.meas tran vdout0_27ck116 FIND v(dout0_27) AT=1170.05n

* CHECK dout0_28 Vdout0_28ck116 = 0 time = 1170
.meas tran vdout0_28ck116 FIND v(dout0_28) AT=1170.05n

* CHECK dout0_29 Vdout0_29ck116 = 0 time = 1170
.meas tran vdout0_29ck116 FIND v(dout0_29) AT=1170.05n

* CHECK dout0_30 Vdout0_30ck116 = 0 time = 1170
.meas tran vdout0_30ck116 FIND v(dout0_30) AT=1170.05n

* CHECK dout0_31 Vdout0_31ck116 = 1.8 time = 1170
.meas tran vdout0_31ck116 FIND v(dout0_31) AT=1170.05n

* CHECK dout0_32 Vdout0_32ck116 = 0 time = 1170
.meas tran vdout0_32ck116 FIND v(dout0_32) AT=1170.05n

* CHECK dout0_0 Vdout0_0ck117 = 0 time = 1180
.meas tran vdout0_0ck117 FIND v(dout0_0) AT=1180.05n

* CHECK dout0_1 Vdout0_1ck117 = 0 time = 1180
.meas tran vdout0_1ck117 FIND v(dout0_1) AT=1180.05n

* CHECK dout0_2 Vdout0_2ck117 = 1.8 time = 1180
.meas tran vdout0_2ck117 FIND v(dout0_2) AT=1180.05n

* CHECK dout0_3 Vdout0_3ck117 = 1.8 time = 1180
.meas tran vdout0_3ck117 FIND v(dout0_3) AT=1180.05n

* CHECK dout0_4 Vdout0_4ck117 = 0 time = 1180
.meas tran vdout0_4ck117 FIND v(dout0_4) AT=1180.05n

* CHECK dout0_5 Vdout0_5ck117 = 1.8 time = 1180
.meas tran vdout0_5ck117 FIND v(dout0_5) AT=1180.05n

* CHECK dout0_6 Vdout0_6ck117 = 1.8 time = 1180
.meas tran vdout0_6ck117 FIND v(dout0_6) AT=1180.05n

* CHECK dout0_7 Vdout0_7ck117 = 0 time = 1180
.meas tran vdout0_7ck117 FIND v(dout0_7) AT=1180.05n

* CHECK dout0_8 Vdout0_8ck117 = 0 time = 1180
.meas tran vdout0_8ck117 FIND v(dout0_8) AT=1180.05n

* CHECK dout0_9 Vdout0_9ck117 = 0 time = 1180
.meas tran vdout0_9ck117 FIND v(dout0_9) AT=1180.05n

* CHECK dout0_10 Vdout0_10ck117 = 0 time = 1180
.meas tran vdout0_10ck117 FIND v(dout0_10) AT=1180.05n

* CHECK dout0_11 Vdout0_11ck117 = 0 time = 1180
.meas tran vdout0_11ck117 FIND v(dout0_11) AT=1180.05n

* CHECK dout0_12 Vdout0_12ck117 = 0 time = 1180
.meas tran vdout0_12ck117 FIND v(dout0_12) AT=1180.05n

* CHECK dout0_13 Vdout0_13ck117 = 0 time = 1180
.meas tran vdout0_13ck117 FIND v(dout0_13) AT=1180.05n

* CHECK dout0_14 Vdout0_14ck117 = 0 time = 1180
.meas tran vdout0_14ck117 FIND v(dout0_14) AT=1180.05n

* CHECK dout0_15 Vdout0_15ck117 = 1.8 time = 1180
.meas tran vdout0_15ck117 FIND v(dout0_15) AT=1180.05n

* CHECK dout0_16 Vdout0_16ck117 = 0 time = 1180
.meas tran vdout0_16ck117 FIND v(dout0_16) AT=1180.05n

* CHECK dout0_17 Vdout0_17ck117 = 0 time = 1180
.meas tran vdout0_17ck117 FIND v(dout0_17) AT=1180.05n

* CHECK dout0_18 Vdout0_18ck117 = 0 time = 1180
.meas tran vdout0_18ck117 FIND v(dout0_18) AT=1180.05n

* CHECK dout0_19 Vdout0_19ck117 = 0 time = 1180
.meas tran vdout0_19ck117 FIND v(dout0_19) AT=1180.05n

* CHECK dout0_20 Vdout0_20ck117 = 1.8 time = 1180
.meas tran vdout0_20ck117 FIND v(dout0_20) AT=1180.05n

* CHECK dout0_21 Vdout0_21ck117 = 1.8 time = 1180
.meas tran vdout0_21ck117 FIND v(dout0_21) AT=1180.05n

* CHECK dout0_22 Vdout0_22ck117 = 0 time = 1180
.meas tran vdout0_22ck117 FIND v(dout0_22) AT=1180.05n

* CHECK dout0_23 Vdout0_23ck117 = 0 time = 1180
.meas tran vdout0_23ck117 FIND v(dout0_23) AT=1180.05n

* CHECK dout0_24 Vdout0_24ck117 = 1.8 time = 1180
.meas tran vdout0_24ck117 FIND v(dout0_24) AT=1180.05n

* CHECK dout0_25 Vdout0_25ck117 = 0 time = 1180
.meas tran vdout0_25ck117 FIND v(dout0_25) AT=1180.05n

* CHECK dout0_26 Vdout0_26ck117 = 1.8 time = 1180
.meas tran vdout0_26ck117 FIND v(dout0_26) AT=1180.05n

* CHECK dout0_27 Vdout0_27ck117 = 0 time = 1180
.meas tran vdout0_27ck117 FIND v(dout0_27) AT=1180.05n

* CHECK dout0_28 Vdout0_28ck117 = 0 time = 1180
.meas tran vdout0_28ck117 FIND v(dout0_28) AT=1180.05n

* CHECK dout0_29 Vdout0_29ck117 = 0 time = 1180
.meas tran vdout0_29ck117 FIND v(dout0_29) AT=1180.05n

* CHECK dout0_30 Vdout0_30ck117 = 0 time = 1180
.meas tran vdout0_30ck117 FIND v(dout0_30) AT=1180.05n

* CHECK dout0_31 Vdout0_31ck117 = 1.8 time = 1180
.meas tran vdout0_31ck117 FIND v(dout0_31) AT=1180.05n

* CHECK dout0_32 Vdout0_32ck117 = 0 time = 1180
.meas tran vdout0_32ck117 FIND v(dout0_32) AT=1180.05n

* CHECK dout0_0 Vdout0_0ck118 = 0 time = 1190
.meas tran vdout0_0ck118 FIND v(dout0_0) AT=1190.05n

* CHECK dout0_1 Vdout0_1ck118 = 0 time = 1190
.meas tran vdout0_1ck118 FIND v(dout0_1) AT=1190.05n

* CHECK dout0_2 Vdout0_2ck118 = 1.8 time = 1190
.meas tran vdout0_2ck118 FIND v(dout0_2) AT=1190.05n

* CHECK dout0_3 Vdout0_3ck118 = 1.8 time = 1190
.meas tran vdout0_3ck118 FIND v(dout0_3) AT=1190.05n

* CHECK dout0_4 Vdout0_4ck118 = 0 time = 1190
.meas tran vdout0_4ck118 FIND v(dout0_4) AT=1190.05n

* CHECK dout0_5 Vdout0_5ck118 = 1.8 time = 1190
.meas tran vdout0_5ck118 FIND v(dout0_5) AT=1190.05n

* CHECK dout0_6 Vdout0_6ck118 = 1.8 time = 1190
.meas tran vdout0_6ck118 FIND v(dout0_6) AT=1190.05n

* CHECK dout0_7 Vdout0_7ck118 = 0 time = 1190
.meas tran vdout0_7ck118 FIND v(dout0_7) AT=1190.05n

* CHECK dout0_8 Vdout0_8ck118 = 0 time = 1190
.meas tran vdout0_8ck118 FIND v(dout0_8) AT=1190.05n

* CHECK dout0_9 Vdout0_9ck118 = 0 time = 1190
.meas tran vdout0_9ck118 FIND v(dout0_9) AT=1190.05n

* CHECK dout0_10 Vdout0_10ck118 = 0 time = 1190
.meas tran vdout0_10ck118 FIND v(dout0_10) AT=1190.05n

* CHECK dout0_11 Vdout0_11ck118 = 0 time = 1190
.meas tran vdout0_11ck118 FIND v(dout0_11) AT=1190.05n

* CHECK dout0_12 Vdout0_12ck118 = 0 time = 1190
.meas tran vdout0_12ck118 FIND v(dout0_12) AT=1190.05n

* CHECK dout0_13 Vdout0_13ck118 = 0 time = 1190
.meas tran vdout0_13ck118 FIND v(dout0_13) AT=1190.05n

* CHECK dout0_14 Vdout0_14ck118 = 0 time = 1190
.meas tran vdout0_14ck118 FIND v(dout0_14) AT=1190.05n

* CHECK dout0_15 Vdout0_15ck118 = 1.8 time = 1190
.meas tran vdout0_15ck118 FIND v(dout0_15) AT=1190.05n

* CHECK dout0_16 Vdout0_16ck118 = 0 time = 1190
.meas tran vdout0_16ck118 FIND v(dout0_16) AT=1190.05n

* CHECK dout0_17 Vdout0_17ck118 = 0 time = 1190
.meas tran vdout0_17ck118 FIND v(dout0_17) AT=1190.05n

* CHECK dout0_18 Vdout0_18ck118 = 0 time = 1190
.meas tran vdout0_18ck118 FIND v(dout0_18) AT=1190.05n

* CHECK dout0_19 Vdout0_19ck118 = 0 time = 1190
.meas tran vdout0_19ck118 FIND v(dout0_19) AT=1190.05n

* CHECK dout0_20 Vdout0_20ck118 = 1.8 time = 1190
.meas tran vdout0_20ck118 FIND v(dout0_20) AT=1190.05n

* CHECK dout0_21 Vdout0_21ck118 = 1.8 time = 1190
.meas tran vdout0_21ck118 FIND v(dout0_21) AT=1190.05n

* CHECK dout0_22 Vdout0_22ck118 = 0 time = 1190
.meas tran vdout0_22ck118 FIND v(dout0_22) AT=1190.05n

* CHECK dout0_23 Vdout0_23ck118 = 0 time = 1190
.meas tran vdout0_23ck118 FIND v(dout0_23) AT=1190.05n

* CHECK dout0_24 Vdout0_24ck118 = 1.8 time = 1190
.meas tran vdout0_24ck118 FIND v(dout0_24) AT=1190.05n

* CHECK dout0_25 Vdout0_25ck118 = 0 time = 1190
.meas tran vdout0_25ck118 FIND v(dout0_25) AT=1190.05n

* CHECK dout0_26 Vdout0_26ck118 = 1.8 time = 1190
.meas tran vdout0_26ck118 FIND v(dout0_26) AT=1190.05n

* CHECK dout0_27 Vdout0_27ck118 = 0 time = 1190
.meas tran vdout0_27ck118 FIND v(dout0_27) AT=1190.05n

* CHECK dout0_28 Vdout0_28ck118 = 0 time = 1190
.meas tran vdout0_28ck118 FIND v(dout0_28) AT=1190.05n

* CHECK dout0_29 Vdout0_29ck118 = 0 time = 1190
.meas tran vdout0_29ck118 FIND v(dout0_29) AT=1190.05n

* CHECK dout0_30 Vdout0_30ck118 = 0 time = 1190
.meas tran vdout0_30ck118 FIND v(dout0_30) AT=1190.05n

* CHECK dout0_31 Vdout0_31ck118 = 1.8 time = 1190
.meas tran vdout0_31ck118 FIND v(dout0_31) AT=1190.05n

* CHECK dout0_32 Vdout0_32ck118 = 0 time = 1190
.meas tran vdout0_32ck118 FIND v(dout0_32) AT=1190.05n

* CHECK dout0_0 Vdout0_0ck120 = 0 time = 1210
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=1210.05n

* CHECK dout0_1 Vdout0_1ck120 = 0 time = 1210
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=1210.05n

* CHECK dout0_2 Vdout0_2ck120 = 1.8 time = 1210
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=1210.05n

* CHECK dout0_3 Vdout0_3ck120 = 1.8 time = 1210
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=1210.05n

* CHECK dout0_4 Vdout0_4ck120 = 0 time = 1210
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=1210.05n

* CHECK dout0_5 Vdout0_5ck120 = 1.8 time = 1210
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=1210.05n

* CHECK dout0_6 Vdout0_6ck120 = 1.8 time = 1210
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=1210.05n

* CHECK dout0_7 Vdout0_7ck120 = 0 time = 1210
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=1210.05n

* CHECK dout0_8 Vdout0_8ck120 = 0 time = 1210
.meas tran vdout0_8ck120 FIND v(dout0_8) AT=1210.05n

* CHECK dout0_9 Vdout0_9ck120 = 0 time = 1210
.meas tran vdout0_9ck120 FIND v(dout0_9) AT=1210.05n

* CHECK dout0_10 Vdout0_10ck120 = 0 time = 1210
.meas tran vdout0_10ck120 FIND v(dout0_10) AT=1210.05n

* CHECK dout0_11 Vdout0_11ck120 = 0 time = 1210
.meas tran vdout0_11ck120 FIND v(dout0_11) AT=1210.05n

* CHECK dout0_12 Vdout0_12ck120 = 0 time = 1210
.meas tran vdout0_12ck120 FIND v(dout0_12) AT=1210.05n

* CHECK dout0_13 Vdout0_13ck120 = 0 time = 1210
.meas tran vdout0_13ck120 FIND v(dout0_13) AT=1210.05n

* CHECK dout0_14 Vdout0_14ck120 = 0 time = 1210
.meas tran vdout0_14ck120 FIND v(dout0_14) AT=1210.05n

* CHECK dout0_15 Vdout0_15ck120 = 1.8 time = 1210
.meas tran vdout0_15ck120 FIND v(dout0_15) AT=1210.05n

* CHECK dout0_16 Vdout0_16ck120 = 0 time = 1210
.meas tran vdout0_16ck120 FIND v(dout0_16) AT=1210.05n

* CHECK dout0_17 Vdout0_17ck120 = 0 time = 1210
.meas tran vdout0_17ck120 FIND v(dout0_17) AT=1210.05n

* CHECK dout0_18 Vdout0_18ck120 = 0 time = 1210
.meas tran vdout0_18ck120 FIND v(dout0_18) AT=1210.05n

* CHECK dout0_19 Vdout0_19ck120 = 0 time = 1210
.meas tran vdout0_19ck120 FIND v(dout0_19) AT=1210.05n

* CHECK dout0_20 Vdout0_20ck120 = 1.8 time = 1210
.meas tran vdout0_20ck120 FIND v(dout0_20) AT=1210.05n

* CHECK dout0_21 Vdout0_21ck120 = 1.8 time = 1210
.meas tran vdout0_21ck120 FIND v(dout0_21) AT=1210.05n

* CHECK dout0_22 Vdout0_22ck120 = 0 time = 1210
.meas tran vdout0_22ck120 FIND v(dout0_22) AT=1210.05n

* CHECK dout0_23 Vdout0_23ck120 = 0 time = 1210
.meas tran vdout0_23ck120 FIND v(dout0_23) AT=1210.05n

* CHECK dout0_24 Vdout0_24ck120 = 1.8 time = 1210
.meas tran vdout0_24ck120 FIND v(dout0_24) AT=1210.05n

* CHECK dout0_25 Vdout0_25ck120 = 0 time = 1210
.meas tran vdout0_25ck120 FIND v(dout0_25) AT=1210.05n

* CHECK dout0_26 Vdout0_26ck120 = 1.8 time = 1210
.meas tran vdout0_26ck120 FIND v(dout0_26) AT=1210.05n

* CHECK dout0_27 Vdout0_27ck120 = 0 time = 1210
.meas tran vdout0_27ck120 FIND v(dout0_27) AT=1210.05n

* CHECK dout0_28 Vdout0_28ck120 = 0 time = 1210
.meas tran vdout0_28ck120 FIND v(dout0_28) AT=1210.05n

* CHECK dout0_29 Vdout0_29ck120 = 0 time = 1210
.meas tran vdout0_29ck120 FIND v(dout0_29) AT=1210.05n

* CHECK dout0_30 Vdout0_30ck120 = 0 time = 1210
.meas tran vdout0_30ck120 FIND v(dout0_30) AT=1210.05n

* CHECK dout0_31 Vdout0_31ck120 = 1.8 time = 1210
.meas tran vdout0_31ck120 FIND v(dout0_31) AT=1210.05n

* CHECK dout0_32 Vdout0_32ck120 = 0 time = 1210
.meas tran vdout0_32ck120 FIND v(dout0_32) AT=1210.05n

* CHECK dout0_0 Vdout0_0ck122 = 1.8 time = 1230
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=1230.05n

* CHECK dout0_1 Vdout0_1ck122 = 1.8 time = 1230
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=1230.05n

* CHECK dout0_2 Vdout0_2ck122 = 0 time = 1230
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=1230.05n

* CHECK dout0_3 Vdout0_3ck122 = 0 time = 1230
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=1230.05n

* CHECK dout0_4 Vdout0_4ck122 = 0 time = 1230
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=1230.05n

* CHECK dout0_5 Vdout0_5ck122 = 0 time = 1230
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=1230.05n

* CHECK dout0_6 Vdout0_6ck122 = 1.8 time = 1230
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=1230.05n

* CHECK dout0_7 Vdout0_7ck122 = 0 time = 1230
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=1230.05n

* CHECK dout0_8 Vdout0_8ck122 = 0 time = 1230
.meas tran vdout0_8ck122 FIND v(dout0_8) AT=1230.05n

* CHECK dout0_9 Vdout0_9ck122 = 1.8 time = 1230
.meas tran vdout0_9ck122 FIND v(dout0_9) AT=1230.05n

* CHECK dout0_10 Vdout0_10ck122 = 0 time = 1230
.meas tran vdout0_10ck122 FIND v(dout0_10) AT=1230.05n

* CHECK dout0_11 Vdout0_11ck122 = 0 time = 1230
.meas tran vdout0_11ck122 FIND v(dout0_11) AT=1230.05n

* CHECK dout0_12 Vdout0_12ck122 = 0 time = 1230
.meas tran vdout0_12ck122 FIND v(dout0_12) AT=1230.05n

* CHECK dout0_13 Vdout0_13ck122 = 0 time = 1230
.meas tran vdout0_13ck122 FIND v(dout0_13) AT=1230.05n

* CHECK dout0_14 Vdout0_14ck122 = 0 time = 1230
.meas tran vdout0_14ck122 FIND v(dout0_14) AT=1230.05n

* CHECK dout0_15 Vdout0_15ck122 = 0 time = 1230
.meas tran vdout0_15ck122 FIND v(dout0_15) AT=1230.05n

* CHECK dout0_16 Vdout0_16ck122 = 1.8 time = 1230
.meas tran vdout0_16ck122 FIND v(dout0_16) AT=1230.05n

* CHECK dout0_17 Vdout0_17ck122 = 0 time = 1230
.meas tran vdout0_17ck122 FIND v(dout0_17) AT=1230.05n

* CHECK dout0_18 Vdout0_18ck122 = 0 time = 1230
.meas tran vdout0_18ck122 FIND v(dout0_18) AT=1230.05n

* CHECK dout0_19 Vdout0_19ck122 = 1.8 time = 1230
.meas tran vdout0_19ck122 FIND v(dout0_19) AT=1230.05n

* CHECK dout0_20 Vdout0_20ck122 = 1.8 time = 1230
.meas tran vdout0_20ck122 FIND v(dout0_20) AT=1230.05n

* CHECK dout0_21 Vdout0_21ck122 = 0 time = 1230
.meas tran vdout0_21ck122 FIND v(dout0_21) AT=1230.05n

* CHECK dout0_22 Vdout0_22ck122 = 1.8 time = 1230
.meas tran vdout0_22ck122 FIND v(dout0_22) AT=1230.05n

* CHECK dout0_23 Vdout0_23ck122 = 0 time = 1230
.meas tran vdout0_23ck122 FIND v(dout0_23) AT=1230.05n

* CHECK dout0_24 Vdout0_24ck122 = 0 time = 1230
.meas tran vdout0_24ck122 FIND v(dout0_24) AT=1230.05n

* CHECK dout0_25 Vdout0_25ck122 = 0 time = 1230
.meas tran vdout0_25ck122 FIND v(dout0_25) AT=1230.05n

* CHECK dout0_26 Vdout0_26ck122 = 0 time = 1230
.meas tran vdout0_26ck122 FIND v(dout0_26) AT=1230.05n

* CHECK dout0_27 Vdout0_27ck122 = 0 time = 1230
.meas tran vdout0_27ck122 FIND v(dout0_27) AT=1230.05n

* CHECK dout0_28 Vdout0_28ck122 = 0 time = 1230
.meas tran vdout0_28ck122 FIND v(dout0_28) AT=1230.05n

* CHECK dout0_29 Vdout0_29ck122 = 1.8 time = 1230
.meas tran vdout0_29ck122 FIND v(dout0_29) AT=1230.05n

* CHECK dout0_30 Vdout0_30ck122 = 0 time = 1230
.meas tran vdout0_30ck122 FIND v(dout0_30) AT=1230.05n

* CHECK dout0_31 Vdout0_31ck122 = 1.8 time = 1230
.meas tran vdout0_31ck122 FIND v(dout0_31) AT=1230.05n

* CHECK dout0_32 Vdout0_32ck122 = 0 time = 1230
.meas tran vdout0_32ck122 FIND v(dout0_32) AT=1230.05n

* CHECK dout0_0 Vdout0_0ck123 = 1.8 time = 1240
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=1240.05n

* CHECK dout0_1 Vdout0_1ck123 = 1.8 time = 1240
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=1240.05n

* CHECK dout0_2 Vdout0_2ck123 = 0 time = 1240
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=1240.05n

* CHECK dout0_3 Vdout0_3ck123 = 0 time = 1240
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=1240.05n

* CHECK dout0_4 Vdout0_4ck123 = 0 time = 1240
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=1240.05n

* CHECK dout0_5 Vdout0_5ck123 = 0 time = 1240
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=1240.05n

* CHECK dout0_6 Vdout0_6ck123 = 1.8 time = 1240
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=1240.05n

* CHECK dout0_7 Vdout0_7ck123 = 0 time = 1240
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=1240.05n

* CHECK dout0_8 Vdout0_8ck123 = 0 time = 1240
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=1240.05n

* CHECK dout0_9 Vdout0_9ck123 = 1.8 time = 1240
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=1240.05n

* CHECK dout0_10 Vdout0_10ck123 = 0 time = 1240
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=1240.05n

* CHECK dout0_11 Vdout0_11ck123 = 0 time = 1240
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=1240.05n

* CHECK dout0_12 Vdout0_12ck123 = 0 time = 1240
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=1240.05n

* CHECK dout0_13 Vdout0_13ck123 = 0 time = 1240
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=1240.05n

* CHECK dout0_14 Vdout0_14ck123 = 0 time = 1240
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=1240.05n

* CHECK dout0_15 Vdout0_15ck123 = 0 time = 1240
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=1240.05n

* CHECK dout0_16 Vdout0_16ck123 = 1.8 time = 1240
.meas tran vdout0_16ck123 FIND v(dout0_16) AT=1240.05n

* CHECK dout0_17 Vdout0_17ck123 = 0 time = 1240
.meas tran vdout0_17ck123 FIND v(dout0_17) AT=1240.05n

* CHECK dout0_18 Vdout0_18ck123 = 0 time = 1240
.meas tran vdout0_18ck123 FIND v(dout0_18) AT=1240.05n

* CHECK dout0_19 Vdout0_19ck123 = 1.8 time = 1240
.meas tran vdout0_19ck123 FIND v(dout0_19) AT=1240.05n

* CHECK dout0_20 Vdout0_20ck123 = 1.8 time = 1240
.meas tran vdout0_20ck123 FIND v(dout0_20) AT=1240.05n

* CHECK dout0_21 Vdout0_21ck123 = 0 time = 1240
.meas tran vdout0_21ck123 FIND v(dout0_21) AT=1240.05n

* CHECK dout0_22 Vdout0_22ck123 = 1.8 time = 1240
.meas tran vdout0_22ck123 FIND v(dout0_22) AT=1240.05n

* CHECK dout0_23 Vdout0_23ck123 = 0 time = 1240
.meas tran vdout0_23ck123 FIND v(dout0_23) AT=1240.05n

* CHECK dout0_24 Vdout0_24ck123 = 0 time = 1240
.meas tran vdout0_24ck123 FIND v(dout0_24) AT=1240.05n

* CHECK dout0_25 Vdout0_25ck123 = 0 time = 1240
.meas tran vdout0_25ck123 FIND v(dout0_25) AT=1240.05n

* CHECK dout0_26 Vdout0_26ck123 = 0 time = 1240
.meas tran vdout0_26ck123 FIND v(dout0_26) AT=1240.05n

* CHECK dout0_27 Vdout0_27ck123 = 0 time = 1240
.meas tran vdout0_27ck123 FIND v(dout0_27) AT=1240.05n

* CHECK dout0_28 Vdout0_28ck123 = 0 time = 1240
.meas tran vdout0_28ck123 FIND v(dout0_28) AT=1240.05n

* CHECK dout0_29 Vdout0_29ck123 = 1.8 time = 1240
.meas tran vdout0_29ck123 FIND v(dout0_29) AT=1240.05n

* CHECK dout0_30 Vdout0_30ck123 = 0 time = 1240
.meas tran vdout0_30ck123 FIND v(dout0_30) AT=1240.05n

* CHECK dout0_31 Vdout0_31ck123 = 1.8 time = 1240
.meas tran vdout0_31ck123 FIND v(dout0_31) AT=1240.05n

* CHECK dout0_32 Vdout0_32ck123 = 0 time = 1240
.meas tran vdout0_32ck123 FIND v(dout0_32) AT=1240.05n

* CHECK dout0_0 Vdout0_0ck125 = 1.8 time = 1260
.meas tran vdout0_0ck125 FIND v(dout0_0) AT=1260.05n

* CHECK dout0_1 Vdout0_1ck125 = 0 time = 1260
.meas tran vdout0_1ck125 FIND v(dout0_1) AT=1260.05n

* CHECK dout0_2 Vdout0_2ck125 = 0 time = 1260
.meas tran vdout0_2ck125 FIND v(dout0_2) AT=1260.05n

* CHECK dout0_3 Vdout0_3ck125 = 1.8 time = 1260
.meas tran vdout0_3ck125 FIND v(dout0_3) AT=1260.05n

* CHECK dout0_4 Vdout0_4ck125 = 1.8 time = 1260
.meas tran vdout0_4ck125 FIND v(dout0_4) AT=1260.05n

* CHECK dout0_5 Vdout0_5ck125 = 1.8 time = 1260
.meas tran vdout0_5ck125 FIND v(dout0_5) AT=1260.05n

* CHECK dout0_6 Vdout0_6ck125 = 1.8 time = 1260
.meas tran vdout0_6ck125 FIND v(dout0_6) AT=1260.05n

* CHECK dout0_7 Vdout0_7ck125 = 1.8 time = 1260
.meas tran vdout0_7ck125 FIND v(dout0_7) AT=1260.05n

* CHECK dout0_8 Vdout0_8ck125 = 0 time = 1260
.meas tran vdout0_8ck125 FIND v(dout0_8) AT=1260.05n

* CHECK dout0_9 Vdout0_9ck125 = 0 time = 1260
.meas tran vdout0_9ck125 FIND v(dout0_9) AT=1260.05n

* CHECK dout0_10 Vdout0_10ck125 = 1.8 time = 1260
.meas tran vdout0_10ck125 FIND v(dout0_10) AT=1260.05n

* CHECK dout0_11 Vdout0_11ck125 = 0 time = 1260
.meas tran vdout0_11ck125 FIND v(dout0_11) AT=1260.05n

* CHECK dout0_12 Vdout0_12ck125 = 1.8 time = 1260
.meas tran vdout0_12ck125 FIND v(dout0_12) AT=1260.05n

* CHECK dout0_13 Vdout0_13ck125 = 1.8 time = 1260
.meas tran vdout0_13ck125 FIND v(dout0_13) AT=1260.05n

* CHECK dout0_14 Vdout0_14ck125 = 1.8 time = 1260
.meas tran vdout0_14ck125 FIND v(dout0_14) AT=1260.05n

* CHECK dout0_15 Vdout0_15ck125 = 1.8 time = 1260
.meas tran vdout0_15ck125 FIND v(dout0_15) AT=1260.05n

* CHECK dout0_16 Vdout0_16ck125 = 1.8 time = 1260
.meas tran vdout0_16ck125 FIND v(dout0_16) AT=1260.05n

* CHECK dout0_17 Vdout0_17ck125 = 1.8 time = 1260
.meas tran vdout0_17ck125 FIND v(dout0_17) AT=1260.05n

* CHECK dout0_18 Vdout0_18ck125 = 0 time = 1260
.meas tran vdout0_18ck125 FIND v(dout0_18) AT=1260.05n

* CHECK dout0_19 Vdout0_19ck125 = 0 time = 1260
.meas tran vdout0_19ck125 FIND v(dout0_19) AT=1260.05n

* CHECK dout0_20 Vdout0_20ck125 = 1.8 time = 1260
.meas tran vdout0_20ck125 FIND v(dout0_20) AT=1260.05n

* CHECK dout0_21 Vdout0_21ck125 = 0 time = 1260
.meas tran vdout0_21ck125 FIND v(dout0_21) AT=1260.05n

* CHECK dout0_22 Vdout0_22ck125 = 1.8 time = 1260
.meas tran vdout0_22ck125 FIND v(dout0_22) AT=1260.05n

* CHECK dout0_23 Vdout0_23ck125 = 0 time = 1260
.meas tran vdout0_23ck125 FIND v(dout0_23) AT=1260.05n

* CHECK dout0_24 Vdout0_24ck125 = 0 time = 1260
.meas tran vdout0_24ck125 FIND v(dout0_24) AT=1260.05n

* CHECK dout0_25 Vdout0_25ck125 = 1.8 time = 1260
.meas tran vdout0_25ck125 FIND v(dout0_25) AT=1260.05n

* CHECK dout0_26 Vdout0_26ck125 = 0 time = 1260
.meas tran vdout0_26ck125 FIND v(dout0_26) AT=1260.05n

* CHECK dout0_27 Vdout0_27ck125 = 0 time = 1260
.meas tran vdout0_27ck125 FIND v(dout0_27) AT=1260.05n

* CHECK dout0_28 Vdout0_28ck125 = 1.8 time = 1260
.meas tran vdout0_28ck125 FIND v(dout0_28) AT=1260.05n

* CHECK dout0_29 Vdout0_29ck125 = 0 time = 1260
.meas tran vdout0_29ck125 FIND v(dout0_29) AT=1260.05n

* CHECK dout0_30 Vdout0_30ck125 = 1.8 time = 1260
.meas tran vdout0_30ck125 FIND v(dout0_30) AT=1260.05n

* CHECK dout0_31 Vdout0_31ck125 = 0 time = 1260
.meas tran vdout0_31ck125 FIND v(dout0_31) AT=1260.05n

* CHECK dout0_32 Vdout0_32ck125 = 0 time = 1260
.meas tran vdout0_32ck125 FIND v(dout0_32) AT=1260.05n

* CHECK dout0_0 Vdout0_0ck127 = 0 time = 1280
.meas tran vdout0_0ck127 FIND v(dout0_0) AT=1280.05n

* CHECK dout0_1 Vdout0_1ck127 = 0 time = 1280
.meas tran vdout0_1ck127 FIND v(dout0_1) AT=1280.05n

* CHECK dout0_2 Vdout0_2ck127 = 1.8 time = 1280
.meas tran vdout0_2ck127 FIND v(dout0_2) AT=1280.05n

* CHECK dout0_3 Vdout0_3ck127 = 1.8 time = 1280
.meas tran vdout0_3ck127 FIND v(dout0_3) AT=1280.05n

* CHECK dout0_4 Vdout0_4ck127 = 1.8 time = 1280
.meas tran vdout0_4ck127 FIND v(dout0_4) AT=1280.05n

* CHECK dout0_5 Vdout0_5ck127 = 1.8 time = 1280
.meas tran vdout0_5ck127 FIND v(dout0_5) AT=1280.05n

* CHECK dout0_6 Vdout0_6ck127 = 0 time = 1280
.meas tran vdout0_6ck127 FIND v(dout0_6) AT=1280.05n

* CHECK dout0_7 Vdout0_7ck127 = 1.8 time = 1280
.meas tran vdout0_7ck127 FIND v(dout0_7) AT=1280.05n

* CHECK dout0_8 Vdout0_8ck127 = 1.8 time = 1280
.meas tran vdout0_8ck127 FIND v(dout0_8) AT=1280.05n

* CHECK dout0_9 Vdout0_9ck127 = 0 time = 1280
.meas tran vdout0_9ck127 FIND v(dout0_9) AT=1280.05n

* CHECK dout0_10 Vdout0_10ck127 = 0 time = 1280
.meas tran vdout0_10ck127 FIND v(dout0_10) AT=1280.05n

* CHECK dout0_11 Vdout0_11ck127 = 0 time = 1280
.meas tran vdout0_11ck127 FIND v(dout0_11) AT=1280.05n

* CHECK dout0_12 Vdout0_12ck127 = 0 time = 1280
.meas tran vdout0_12ck127 FIND v(dout0_12) AT=1280.05n

* CHECK dout0_13 Vdout0_13ck127 = 0 time = 1280
.meas tran vdout0_13ck127 FIND v(dout0_13) AT=1280.05n

* CHECK dout0_14 Vdout0_14ck127 = 0 time = 1280
.meas tran vdout0_14ck127 FIND v(dout0_14) AT=1280.05n

* CHECK dout0_15 Vdout0_15ck127 = 1.8 time = 1280
.meas tran vdout0_15ck127 FIND v(dout0_15) AT=1280.05n

* CHECK dout0_16 Vdout0_16ck127 = 1.8 time = 1280
.meas tran vdout0_16ck127 FIND v(dout0_16) AT=1280.05n

* CHECK dout0_17 Vdout0_17ck127 = 0 time = 1280
.meas tran vdout0_17ck127 FIND v(dout0_17) AT=1280.05n

* CHECK dout0_18 Vdout0_18ck127 = 1.8 time = 1280
.meas tran vdout0_18ck127 FIND v(dout0_18) AT=1280.05n

* CHECK dout0_19 Vdout0_19ck127 = 0 time = 1280
.meas tran vdout0_19ck127 FIND v(dout0_19) AT=1280.05n

* CHECK dout0_20 Vdout0_20ck127 = 0 time = 1280
.meas tran vdout0_20ck127 FIND v(dout0_20) AT=1280.05n

* CHECK dout0_21 Vdout0_21ck127 = 1.8 time = 1280
.meas tran vdout0_21ck127 FIND v(dout0_21) AT=1280.05n

* CHECK dout0_22 Vdout0_22ck127 = 1.8 time = 1280
.meas tran vdout0_22ck127 FIND v(dout0_22) AT=1280.05n

* CHECK dout0_23 Vdout0_23ck127 = 0 time = 1280
.meas tran vdout0_23ck127 FIND v(dout0_23) AT=1280.05n

* CHECK dout0_24 Vdout0_24ck127 = 0 time = 1280
.meas tran vdout0_24ck127 FIND v(dout0_24) AT=1280.05n

* CHECK dout0_25 Vdout0_25ck127 = 1.8 time = 1280
.meas tran vdout0_25ck127 FIND v(dout0_25) AT=1280.05n

* CHECK dout0_26 Vdout0_26ck127 = 0 time = 1280
.meas tran vdout0_26ck127 FIND v(dout0_26) AT=1280.05n

* CHECK dout0_27 Vdout0_27ck127 = 1.8 time = 1280
.meas tran vdout0_27ck127 FIND v(dout0_27) AT=1280.05n

* CHECK dout0_28 Vdout0_28ck127 = 0 time = 1280
.meas tran vdout0_28ck127 FIND v(dout0_28) AT=1280.05n

* CHECK dout0_29 Vdout0_29ck127 = 1.8 time = 1280
.meas tran vdout0_29ck127 FIND v(dout0_29) AT=1280.05n

* CHECK dout0_30 Vdout0_30ck127 = 1.8 time = 1280
.meas tran vdout0_30ck127 FIND v(dout0_30) AT=1280.05n

* CHECK dout0_31 Vdout0_31ck127 = 1.8 time = 1280
.meas tran vdout0_31ck127 FIND v(dout0_31) AT=1280.05n

* CHECK dout0_32 Vdout0_32ck127 = 0 time = 1280
.meas tran vdout0_32ck127 FIND v(dout0_32) AT=1280.05n

* CHECK dout0_0 Vdout0_0ck128 = 1.8 time = 1290
.meas tran vdout0_0ck128 FIND v(dout0_0) AT=1290.05n

* CHECK dout0_1 Vdout0_1ck128 = 0 time = 1290
.meas tran vdout0_1ck128 FIND v(dout0_1) AT=1290.05n

* CHECK dout0_2 Vdout0_2ck128 = 0 time = 1290
.meas tran vdout0_2ck128 FIND v(dout0_2) AT=1290.05n

* CHECK dout0_3 Vdout0_3ck128 = 1.8 time = 1290
.meas tran vdout0_3ck128 FIND v(dout0_3) AT=1290.05n

* CHECK dout0_4 Vdout0_4ck128 = 1.8 time = 1290
.meas tran vdout0_4ck128 FIND v(dout0_4) AT=1290.05n

* CHECK dout0_5 Vdout0_5ck128 = 1.8 time = 1290
.meas tran vdout0_5ck128 FIND v(dout0_5) AT=1290.05n

* CHECK dout0_6 Vdout0_6ck128 = 1.8 time = 1290
.meas tran vdout0_6ck128 FIND v(dout0_6) AT=1290.05n

* CHECK dout0_7 Vdout0_7ck128 = 1.8 time = 1290
.meas tran vdout0_7ck128 FIND v(dout0_7) AT=1290.05n

* CHECK dout0_8 Vdout0_8ck128 = 0 time = 1290
.meas tran vdout0_8ck128 FIND v(dout0_8) AT=1290.05n

* CHECK dout0_9 Vdout0_9ck128 = 0 time = 1290
.meas tran vdout0_9ck128 FIND v(dout0_9) AT=1290.05n

* CHECK dout0_10 Vdout0_10ck128 = 1.8 time = 1290
.meas tran vdout0_10ck128 FIND v(dout0_10) AT=1290.05n

* CHECK dout0_11 Vdout0_11ck128 = 0 time = 1290
.meas tran vdout0_11ck128 FIND v(dout0_11) AT=1290.05n

* CHECK dout0_12 Vdout0_12ck128 = 1.8 time = 1290
.meas tran vdout0_12ck128 FIND v(dout0_12) AT=1290.05n

* CHECK dout0_13 Vdout0_13ck128 = 1.8 time = 1290
.meas tran vdout0_13ck128 FIND v(dout0_13) AT=1290.05n

* CHECK dout0_14 Vdout0_14ck128 = 1.8 time = 1290
.meas tran vdout0_14ck128 FIND v(dout0_14) AT=1290.05n

* CHECK dout0_15 Vdout0_15ck128 = 1.8 time = 1290
.meas tran vdout0_15ck128 FIND v(dout0_15) AT=1290.05n

* CHECK dout0_16 Vdout0_16ck128 = 1.8 time = 1290
.meas tran vdout0_16ck128 FIND v(dout0_16) AT=1290.05n

* CHECK dout0_17 Vdout0_17ck128 = 1.8 time = 1290
.meas tran vdout0_17ck128 FIND v(dout0_17) AT=1290.05n

* CHECK dout0_18 Vdout0_18ck128 = 0 time = 1290
.meas tran vdout0_18ck128 FIND v(dout0_18) AT=1290.05n

* CHECK dout0_19 Vdout0_19ck128 = 0 time = 1290
.meas tran vdout0_19ck128 FIND v(dout0_19) AT=1290.05n

* CHECK dout0_20 Vdout0_20ck128 = 1.8 time = 1290
.meas tran vdout0_20ck128 FIND v(dout0_20) AT=1290.05n

* CHECK dout0_21 Vdout0_21ck128 = 0 time = 1290
.meas tran vdout0_21ck128 FIND v(dout0_21) AT=1290.05n

* CHECK dout0_22 Vdout0_22ck128 = 1.8 time = 1290
.meas tran vdout0_22ck128 FIND v(dout0_22) AT=1290.05n

* CHECK dout0_23 Vdout0_23ck128 = 0 time = 1290
.meas tran vdout0_23ck128 FIND v(dout0_23) AT=1290.05n

* CHECK dout0_24 Vdout0_24ck128 = 0 time = 1290
.meas tran vdout0_24ck128 FIND v(dout0_24) AT=1290.05n

* CHECK dout0_25 Vdout0_25ck128 = 1.8 time = 1290
.meas tran vdout0_25ck128 FIND v(dout0_25) AT=1290.05n

* CHECK dout0_26 Vdout0_26ck128 = 0 time = 1290
.meas tran vdout0_26ck128 FIND v(dout0_26) AT=1290.05n

* CHECK dout0_27 Vdout0_27ck128 = 0 time = 1290
.meas tran vdout0_27ck128 FIND v(dout0_27) AT=1290.05n

* CHECK dout0_28 Vdout0_28ck128 = 1.8 time = 1290
.meas tran vdout0_28ck128 FIND v(dout0_28) AT=1290.05n

* CHECK dout0_29 Vdout0_29ck128 = 0 time = 1290
.meas tran vdout0_29ck128 FIND v(dout0_29) AT=1290.05n

* CHECK dout0_30 Vdout0_30ck128 = 1.8 time = 1290
.meas tran vdout0_30ck128 FIND v(dout0_30) AT=1290.05n

* CHECK dout0_31 Vdout0_31ck128 = 0 time = 1290
.meas tran vdout0_31ck128 FIND v(dout0_31) AT=1290.05n

* CHECK dout0_32 Vdout0_32ck128 = 0 time = 1290
.meas tran vdout0_32ck128 FIND v(dout0_32) AT=1290.05n

* CHECK dout0_0 Vdout0_0ck133 = 0 time = 1340
.meas tran vdout0_0ck133 FIND v(dout0_0) AT=1340.05n

* CHECK dout0_1 Vdout0_1ck133 = 1.8 time = 1340
.meas tran vdout0_1ck133 FIND v(dout0_1) AT=1340.05n

* CHECK dout0_2 Vdout0_2ck133 = 1.8 time = 1340
.meas tran vdout0_2ck133 FIND v(dout0_2) AT=1340.05n

* CHECK dout0_3 Vdout0_3ck133 = 0 time = 1340
.meas tran vdout0_3ck133 FIND v(dout0_3) AT=1340.05n

* CHECK dout0_4 Vdout0_4ck133 = 0 time = 1340
.meas tran vdout0_4ck133 FIND v(dout0_4) AT=1340.05n

* CHECK dout0_5 Vdout0_5ck133 = 0 time = 1340
.meas tran vdout0_5ck133 FIND v(dout0_5) AT=1340.05n

* CHECK dout0_6 Vdout0_6ck133 = 1.8 time = 1340
.meas tran vdout0_6ck133 FIND v(dout0_6) AT=1340.05n

* CHECK dout0_7 Vdout0_7ck133 = 0 time = 1340
.meas tran vdout0_7ck133 FIND v(dout0_7) AT=1340.05n

* CHECK dout0_8 Vdout0_8ck133 = 1.8 time = 1340
.meas tran vdout0_8ck133 FIND v(dout0_8) AT=1340.05n

* CHECK dout0_9 Vdout0_9ck133 = 1.8 time = 1340
.meas tran vdout0_9ck133 FIND v(dout0_9) AT=1340.05n

* CHECK dout0_10 Vdout0_10ck133 = 0 time = 1340
.meas tran vdout0_10ck133 FIND v(dout0_10) AT=1340.05n

* CHECK dout0_11 Vdout0_11ck133 = 0 time = 1340
.meas tran vdout0_11ck133 FIND v(dout0_11) AT=1340.05n

* CHECK dout0_12 Vdout0_12ck133 = 0 time = 1340
.meas tran vdout0_12ck133 FIND v(dout0_12) AT=1340.05n

* CHECK dout0_13 Vdout0_13ck133 = 1.8 time = 1340
.meas tran vdout0_13ck133 FIND v(dout0_13) AT=1340.05n

* CHECK dout0_14 Vdout0_14ck133 = 0 time = 1340
.meas tran vdout0_14ck133 FIND v(dout0_14) AT=1340.05n

* CHECK dout0_15 Vdout0_15ck133 = 1.8 time = 1340
.meas tran vdout0_15ck133 FIND v(dout0_15) AT=1340.05n

* CHECK dout0_16 Vdout0_16ck133 = 0 time = 1340
.meas tran vdout0_16ck133 FIND v(dout0_16) AT=1340.05n

* CHECK dout0_17 Vdout0_17ck133 = 1.8 time = 1340
.meas tran vdout0_17ck133 FIND v(dout0_17) AT=1340.05n

* CHECK dout0_18 Vdout0_18ck133 = 1.8 time = 1340
.meas tran vdout0_18ck133 FIND v(dout0_18) AT=1340.05n

* CHECK dout0_19 Vdout0_19ck133 = 0 time = 1340
.meas tran vdout0_19ck133 FIND v(dout0_19) AT=1340.05n

* CHECK dout0_20 Vdout0_20ck133 = 0 time = 1340
.meas tran vdout0_20ck133 FIND v(dout0_20) AT=1340.05n

* CHECK dout0_21 Vdout0_21ck133 = 1.8 time = 1340
.meas tran vdout0_21ck133 FIND v(dout0_21) AT=1340.05n

* CHECK dout0_22 Vdout0_22ck133 = 1.8 time = 1340
.meas tran vdout0_22ck133 FIND v(dout0_22) AT=1340.05n

* CHECK dout0_23 Vdout0_23ck133 = 0 time = 1340
.meas tran vdout0_23ck133 FIND v(dout0_23) AT=1340.05n

* CHECK dout0_24 Vdout0_24ck133 = 0 time = 1340
.meas tran vdout0_24ck133 FIND v(dout0_24) AT=1340.05n

* CHECK dout0_25 Vdout0_25ck133 = 1.8 time = 1340
.meas tran vdout0_25ck133 FIND v(dout0_25) AT=1340.05n

* CHECK dout0_26 Vdout0_26ck133 = 0 time = 1340
.meas tran vdout0_26ck133 FIND v(dout0_26) AT=1340.05n

* CHECK dout0_27 Vdout0_27ck133 = 1.8 time = 1340
.meas tran vdout0_27ck133 FIND v(dout0_27) AT=1340.05n

* CHECK dout0_28 Vdout0_28ck133 = 1.8 time = 1340
.meas tran vdout0_28ck133 FIND v(dout0_28) AT=1340.05n

* CHECK dout0_29 Vdout0_29ck133 = 1.8 time = 1340
.meas tran vdout0_29ck133 FIND v(dout0_29) AT=1340.05n

* CHECK dout0_30 Vdout0_30ck133 = 1.8 time = 1340
.meas tran vdout0_30ck133 FIND v(dout0_30) AT=1340.05n

* CHECK dout0_31 Vdout0_31ck133 = 1.8 time = 1340
.meas tran vdout0_31ck133 FIND v(dout0_31) AT=1340.05n

* CHECK dout0_32 Vdout0_32ck133 = 0 time = 1340
.meas tran vdout0_32ck133 FIND v(dout0_32) AT=1340.05n

* CHECK dout0_0 Vdout0_0ck137 = 1.8 time = 1380
.meas tran vdout0_0ck137 FIND v(dout0_0) AT=1380.05n

* CHECK dout0_1 Vdout0_1ck137 = 1.8 time = 1380
.meas tran vdout0_1ck137 FIND v(dout0_1) AT=1380.05n

* CHECK dout0_2 Vdout0_2ck137 = 1.8 time = 1380
.meas tran vdout0_2ck137 FIND v(dout0_2) AT=1380.05n

* CHECK dout0_3 Vdout0_3ck137 = 1.8 time = 1380
.meas tran vdout0_3ck137 FIND v(dout0_3) AT=1380.05n

* CHECK dout0_4 Vdout0_4ck137 = 1.8 time = 1380
.meas tran vdout0_4ck137 FIND v(dout0_4) AT=1380.05n

* CHECK dout0_5 Vdout0_5ck137 = 0 time = 1380
.meas tran vdout0_5ck137 FIND v(dout0_5) AT=1380.05n

* CHECK dout0_6 Vdout0_6ck137 = 1.8 time = 1380
.meas tran vdout0_6ck137 FIND v(dout0_6) AT=1380.05n

* CHECK dout0_7 Vdout0_7ck137 = 1.8 time = 1380
.meas tran vdout0_7ck137 FIND v(dout0_7) AT=1380.05n

* CHECK dout0_8 Vdout0_8ck137 = 1.8 time = 1380
.meas tran vdout0_8ck137 FIND v(dout0_8) AT=1380.05n

* CHECK dout0_9 Vdout0_9ck137 = 1.8 time = 1380
.meas tran vdout0_9ck137 FIND v(dout0_9) AT=1380.05n

* CHECK dout0_10 Vdout0_10ck137 = 1.8 time = 1380
.meas tran vdout0_10ck137 FIND v(dout0_10) AT=1380.05n

* CHECK dout0_11 Vdout0_11ck137 = 1.8 time = 1380
.meas tran vdout0_11ck137 FIND v(dout0_11) AT=1380.05n

* CHECK dout0_12 Vdout0_12ck137 = 1.8 time = 1380
.meas tran vdout0_12ck137 FIND v(dout0_12) AT=1380.05n

* CHECK dout0_13 Vdout0_13ck137 = 1.8 time = 1380
.meas tran vdout0_13ck137 FIND v(dout0_13) AT=1380.05n

* CHECK dout0_14 Vdout0_14ck137 = 1.8 time = 1380
.meas tran vdout0_14ck137 FIND v(dout0_14) AT=1380.05n

* CHECK dout0_15 Vdout0_15ck137 = 1.8 time = 1380
.meas tran vdout0_15ck137 FIND v(dout0_15) AT=1380.05n

* CHECK dout0_16 Vdout0_16ck137 = 1.8 time = 1380
.meas tran vdout0_16ck137 FIND v(dout0_16) AT=1380.05n

* CHECK dout0_17 Vdout0_17ck137 = 1.8 time = 1380
.meas tran vdout0_17ck137 FIND v(dout0_17) AT=1380.05n

* CHECK dout0_18 Vdout0_18ck137 = 0 time = 1380
.meas tran vdout0_18ck137 FIND v(dout0_18) AT=1380.05n

* CHECK dout0_19 Vdout0_19ck137 = 1.8 time = 1380
.meas tran vdout0_19ck137 FIND v(dout0_19) AT=1380.05n

* CHECK dout0_20 Vdout0_20ck137 = 0 time = 1380
.meas tran vdout0_20ck137 FIND v(dout0_20) AT=1380.05n

* CHECK dout0_21 Vdout0_21ck137 = 1.8 time = 1380
.meas tran vdout0_21ck137 FIND v(dout0_21) AT=1380.05n

* CHECK dout0_22 Vdout0_22ck137 = 0 time = 1380
.meas tran vdout0_22ck137 FIND v(dout0_22) AT=1380.05n

* CHECK dout0_23 Vdout0_23ck137 = 1.8 time = 1380
.meas tran vdout0_23ck137 FIND v(dout0_23) AT=1380.05n

* CHECK dout0_24 Vdout0_24ck137 = 1.8 time = 1380
.meas tran vdout0_24ck137 FIND v(dout0_24) AT=1380.05n

* CHECK dout0_25 Vdout0_25ck137 = 1.8 time = 1380
.meas tran vdout0_25ck137 FIND v(dout0_25) AT=1380.05n

* CHECK dout0_26 Vdout0_26ck137 = 0 time = 1380
.meas tran vdout0_26ck137 FIND v(dout0_26) AT=1380.05n

* CHECK dout0_27 Vdout0_27ck137 = 0 time = 1380
.meas tran vdout0_27ck137 FIND v(dout0_27) AT=1380.05n

* CHECK dout0_28 Vdout0_28ck137 = 1.8 time = 1380
.meas tran vdout0_28ck137 FIND v(dout0_28) AT=1380.05n

* CHECK dout0_29 Vdout0_29ck137 = 1.8 time = 1380
.meas tran vdout0_29ck137 FIND v(dout0_29) AT=1380.05n

* CHECK dout0_30 Vdout0_30ck137 = 1.8 time = 1380
.meas tran vdout0_30ck137 FIND v(dout0_30) AT=1380.05n

* CHECK dout0_31 Vdout0_31ck137 = 1.8 time = 1380
.meas tran vdout0_31ck137 FIND v(dout0_31) AT=1380.05n

* CHECK dout0_32 Vdout0_32ck137 = 0 time = 1380
.meas tran vdout0_32ck137 FIND v(dout0_32) AT=1380.05n

* CHECK dout0_0 Vdout0_0ck139 = 1.8 time = 1400
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=1400.05n

* CHECK dout0_1 Vdout0_1ck139 = 1.8 time = 1400
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=1400.05n

* CHECK dout0_2 Vdout0_2ck139 = 1.8 time = 1400
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=1400.05n

* CHECK dout0_3 Vdout0_3ck139 = 1.8 time = 1400
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=1400.05n

* CHECK dout0_4 Vdout0_4ck139 = 1.8 time = 1400
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=1400.05n

* CHECK dout0_5 Vdout0_5ck139 = 0 time = 1400
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=1400.05n

* CHECK dout0_6 Vdout0_6ck139 = 1.8 time = 1400
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=1400.05n

* CHECK dout0_7 Vdout0_7ck139 = 1.8 time = 1400
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=1400.05n

* CHECK dout0_8 Vdout0_8ck139 = 1.8 time = 1400
.meas tran vdout0_8ck139 FIND v(dout0_8) AT=1400.05n

* CHECK dout0_9 Vdout0_9ck139 = 1.8 time = 1400
.meas tran vdout0_9ck139 FIND v(dout0_9) AT=1400.05n

* CHECK dout0_10 Vdout0_10ck139 = 1.8 time = 1400
.meas tran vdout0_10ck139 FIND v(dout0_10) AT=1400.05n

* CHECK dout0_11 Vdout0_11ck139 = 1.8 time = 1400
.meas tran vdout0_11ck139 FIND v(dout0_11) AT=1400.05n

* CHECK dout0_12 Vdout0_12ck139 = 1.8 time = 1400
.meas tran vdout0_12ck139 FIND v(dout0_12) AT=1400.05n

* CHECK dout0_13 Vdout0_13ck139 = 1.8 time = 1400
.meas tran vdout0_13ck139 FIND v(dout0_13) AT=1400.05n

* CHECK dout0_14 Vdout0_14ck139 = 1.8 time = 1400
.meas tran vdout0_14ck139 FIND v(dout0_14) AT=1400.05n

* CHECK dout0_15 Vdout0_15ck139 = 1.8 time = 1400
.meas tran vdout0_15ck139 FIND v(dout0_15) AT=1400.05n

* CHECK dout0_16 Vdout0_16ck139 = 1.8 time = 1400
.meas tran vdout0_16ck139 FIND v(dout0_16) AT=1400.05n

* CHECK dout0_17 Vdout0_17ck139 = 1.8 time = 1400
.meas tran vdout0_17ck139 FIND v(dout0_17) AT=1400.05n

* CHECK dout0_18 Vdout0_18ck139 = 0 time = 1400
.meas tran vdout0_18ck139 FIND v(dout0_18) AT=1400.05n

* CHECK dout0_19 Vdout0_19ck139 = 1.8 time = 1400
.meas tran vdout0_19ck139 FIND v(dout0_19) AT=1400.05n

* CHECK dout0_20 Vdout0_20ck139 = 0 time = 1400
.meas tran vdout0_20ck139 FIND v(dout0_20) AT=1400.05n

* CHECK dout0_21 Vdout0_21ck139 = 1.8 time = 1400
.meas tran vdout0_21ck139 FIND v(dout0_21) AT=1400.05n

* CHECK dout0_22 Vdout0_22ck139 = 0 time = 1400
.meas tran vdout0_22ck139 FIND v(dout0_22) AT=1400.05n

* CHECK dout0_23 Vdout0_23ck139 = 1.8 time = 1400
.meas tran vdout0_23ck139 FIND v(dout0_23) AT=1400.05n

* CHECK dout0_24 Vdout0_24ck139 = 1.8 time = 1400
.meas tran vdout0_24ck139 FIND v(dout0_24) AT=1400.05n

* CHECK dout0_25 Vdout0_25ck139 = 1.8 time = 1400
.meas tran vdout0_25ck139 FIND v(dout0_25) AT=1400.05n

* CHECK dout0_26 Vdout0_26ck139 = 0 time = 1400
.meas tran vdout0_26ck139 FIND v(dout0_26) AT=1400.05n

* CHECK dout0_27 Vdout0_27ck139 = 0 time = 1400
.meas tran vdout0_27ck139 FIND v(dout0_27) AT=1400.05n

* CHECK dout0_28 Vdout0_28ck139 = 1.8 time = 1400
.meas tran vdout0_28ck139 FIND v(dout0_28) AT=1400.05n

* CHECK dout0_29 Vdout0_29ck139 = 1.8 time = 1400
.meas tran vdout0_29ck139 FIND v(dout0_29) AT=1400.05n

* CHECK dout0_30 Vdout0_30ck139 = 1.8 time = 1400
.meas tran vdout0_30ck139 FIND v(dout0_30) AT=1400.05n

* CHECK dout0_31 Vdout0_31ck139 = 1.8 time = 1400
.meas tran vdout0_31ck139 FIND v(dout0_31) AT=1400.05n

* CHECK dout0_32 Vdout0_32ck139 = 0 time = 1400
.meas tran vdout0_32ck139 FIND v(dout0_32) AT=1400.05n

* CHECK dout0_0 Vdout0_0ck140 = 1.8 time = 1410
.meas tran vdout0_0ck140 FIND v(dout0_0) AT=1410.05n

* CHECK dout0_1 Vdout0_1ck140 = 0 time = 1410
.meas tran vdout0_1ck140 FIND v(dout0_1) AT=1410.05n

* CHECK dout0_2 Vdout0_2ck140 = 1.8 time = 1410
.meas tran vdout0_2ck140 FIND v(dout0_2) AT=1410.05n

* CHECK dout0_3 Vdout0_3ck140 = 1.8 time = 1410
.meas tran vdout0_3ck140 FIND v(dout0_3) AT=1410.05n

* CHECK dout0_4 Vdout0_4ck140 = 1.8 time = 1410
.meas tran vdout0_4ck140 FIND v(dout0_4) AT=1410.05n

* CHECK dout0_5 Vdout0_5ck140 = 1.8 time = 1410
.meas tran vdout0_5ck140 FIND v(dout0_5) AT=1410.05n

* CHECK dout0_6 Vdout0_6ck140 = 1.8 time = 1410
.meas tran vdout0_6ck140 FIND v(dout0_6) AT=1410.05n

* CHECK dout0_7 Vdout0_7ck140 = 0 time = 1410
.meas tran vdout0_7ck140 FIND v(dout0_7) AT=1410.05n

* CHECK dout0_8 Vdout0_8ck140 = 1.8 time = 1410
.meas tran vdout0_8ck140 FIND v(dout0_8) AT=1410.05n

* CHECK dout0_9 Vdout0_9ck140 = 1.8 time = 1410
.meas tran vdout0_9ck140 FIND v(dout0_9) AT=1410.05n

* CHECK dout0_10 Vdout0_10ck140 = 1.8 time = 1410
.meas tran vdout0_10ck140 FIND v(dout0_10) AT=1410.05n

* CHECK dout0_11 Vdout0_11ck140 = 0 time = 1410
.meas tran vdout0_11ck140 FIND v(dout0_11) AT=1410.05n

* CHECK dout0_12 Vdout0_12ck140 = 0 time = 1410
.meas tran vdout0_12ck140 FIND v(dout0_12) AT=1410.05n

* CHECK dout0_13 Vdout0_13ck140 = 1.8 time = 1410
.meas tran vdout0_13ck140 FIND v(dout0_13) AT=1410.05n

* CHECK dout0_14 Vdout0_14ck140 = 0 time = 1410
.meas tran vdout0_14ck140 FIND v(dout0_14) AT=1410.05n

* CHECK dout0_15 Vdout0_15ck140 = 1.8 time = 1410
.meas tran vdout0_15ck140 FIND v(dout0_15) AT=1410.05n

* CHECK dout0_16 Vdout0_16ck140 = 0 time = 1410
.meas tran vdout0_16ck140 FIND v(dout0_16) AT=1410.05n

* CHECK dout0_17 Vdout0_17ck140 = 1.8 time = 1410
.meas tran vdout0_17ck140 FIND v(dout0_17) AT=1410.05n

* CHECK dout0_18 Vdout0_18ck140 = 1.8 time = 1410
.meas tran vdout0_18ck140 FIND v(dout0_18) AT=1410.05n

* CHECK dout0_19 Vdout0_19ck140 = 0 time = 1410
.meas tran vdout0_19ck140 FIND v(dout0_19) AT=1410.05n

* CHECK dout0_20 Vdout0_20ck140 = 0 time = 1410
.meas tran vdout0_20ck140 FIND v(dout0_20) AT=1410.05n

* CHECK dout0_21 Vdout0_21ck140 = 0 time = 1410
.meas tran vdout0_21ck140 FIND v(dout0_21) AT=1410.05n

* CHECK dout0_22 Vdout0_22ck140 = 1.8 time = 1410
.meas tran vdout0_22ck140 FIND v(dout0_22) AT=1410.05n

* CHECK dout0_23 Vdout0_23ck140 = 1.8 time = 1410
.meas tran vdout0_23ck140 FIND v(dout0_23) AT=1410.05n

* CHECK dout0_24 Vdout0_24ck140 = 1.8 time = 1410
.meas tran vdout0_24ck140 FIND v(dout0_24) AT=1410.05n

* CHECK dout0_25 Vdout0_25ck140 = 0 time = 1410
.meas tran vdout0_25ck140 FIND v(dout0_25) AT=1410.05n

* CHECK dout0_26 Vdout0_26ck140 = 1.8 time = 1410
.meas tran vdout0_26ck140 FIND v(dout0_26) AT=1410.05n

* CHECK dout0_27 Vdout0_27ck140 = 0 time = 1410
.meas tran vdout0_27ck140 FIND v(dout0_27) AT=1410.05n

* CHECK dout0_28 Vdout0_28ck140 = 0 time = 1410
.meas tran vdout0_28ck140 FIND v(dout0_28) AT=1410.05n

* CHECK dout0_29 Vdout0_29ck140 = 1.8 time = 1410
.meas tran vdout0_29ck140 FIND v(dout0_29) AT=1410.05n

* CHECK dout0_30 Vdout0_30ck140 = 1.8 time = 1410
.meas tran vdout0_30ck140 FIND v(dout0_30) AT=1410.05n

* CHECK dout0_31 Vdout0_31ck140 = 1.8 time = 1410
.meas tran vdout0_31ck140 FIND v(dout0_31) AT=1410.05n

* CHECK dout0_32 Vdout0_32ck140 = 0 time = 1410
.meas tran vdout0_32ck140 FIND v(dout0_32) AT=1410.05n

* CHECK dout0_0 Vdout0_0ck142 = 1.8 time = 1430
.meas tran vdout0_0ck142 FIND v(dout0_0) AT=1430.05n

* CHECK dout0_1 Vdout0_1ck142 = 1.8 time = 1430
.meas tran vdout0_1ck142 FIND v(dout0_1) AT=1430.05n

* CHECK dout0_2 Vdout0_2ck142 = 1.8 time = 1430
.meas tran vdout0_2ck142 FIND v(dout0_2) AT=1430.05n

* CHECK dout0_3 Vdout0_3ck142 = 1.8 time = 1430
.meas tran vdout0_3ck142 FIND v(dout0_3) AT=1430.05n

* CHECK dout0_4 Vdout0_4ck142 = 1.8 time = 1430
.meas tran vdout0_4ck142 FIND v(dout0_4) AT=1430.05n

* CHECK dout0_5 Vdout0_5ck142 = 0 time = 1430
.meas tran vdout0_5ck142 FIND v(dout0_5) AT=1430.05n

* CHECK dout0_6 Vdout0_6ck142 = 1.8 time = 1430
.meas tran vdout0_6ck142 FIND v(dout0_6) AT=1430.05n

* CHECK dout0_7 Vdout0_7ck142 = 1.8 time = 1430
.meas tran vdout0_7ck142 FIND v(dout0_7) AT=1430.05n

* CHECK dout0_8 Vdout0_8ck142 = 1.8 time = 1430
.meas tran vdout0_8ck142 FIND v(dout0_8) AT=1430.05n

* CHECK dout0_9 Vdout0_9ck142 = 1.8 time = 1430
.meas tran vdout0_9ck142 FIND v(dout0_9) AT=1430.05n

* CHECK dout0_10 Vdout0_10ck142 = 1.8 time = 1430
.meas tran vdout0_10ck142 FIND v(dout0_10) AT=1430.05n

* CHECK dout0_11 Vdout0_11ck142 = 1.8 time = 1430
.meas tran vdout0_11ck142 FIND v(dout0_11) AT=1430.05n

* CHECK dout0_12 Vdout0_12ck142 = 1.8 time = 1430
.meas tran vdout0_12ck142 FIND v(dout0_12) AT=1430.05n

* CHECK dout0_13 Vdout0_13ck142 = 1.8 time = 1430
.meas tran vdout0_13ck142 FIND v(dout0_13) AT=1430.05n

* CHECK dout0_14 Vdout0_14ck142 = 1.8 time = 1430
.meas tran vdout0_14ck142 FIND v(dout0_14) AT=1430.05n

* CHECK dout0_15 Vdout0_15ck142 = 1.8 time = 1430
.meas tran vdout0_15ck142 FIND v(dout0_15) AT=1430.05n

* CHECK dout0_16 Vdout0_16ck142 = 1.8 time = 1430
.meas tran vdout0_16ck142 FIND v(dout0_16) AT=1430.05n

* CHECK dout0_17 Vdout0_17ck142 = 1.8 time = 1430
.meas tran vdout0_17ck142 FIND v(dout0_17) AT=1430.05n

* CHECK dout0_18 Vdout0_18ck142 = 0 time = 1430
.meas tran vdout0_18ck142 FIND v(dout0_18) AT=1430.05n

* CHECK dout0_19 Vdout0_19ck142 = 1.8 time = 1430
.meas tran vdout0_19ck142 FIND v(dout0_19) AT=1430.05n

* CHECK dout0_20 Vdout0_20ck142 = 0 time = 1430
.meas tran vdout0_20ck142 FIND v(dout0_20) AT=1430.05n

* CHECK dout0_21 Vdout0_21ck142 = 1.8 time = 1430
.meas tran vdout0_21ck142 FIND v(dout0_21) AT=1430.05n

* CHECK dout0_22 Vdout0_22ck142 = 0 time = 1430
.meas tran vdout0_22ck142 FIND v(dout0_22) AT=1430.05n

* CHECK dout0_23 Vdout0_23ck142 = 1.8 time = 1430
.meas tran vdout0_23ck142 FIND v(dout0_23) AT=1430.05n

* CHECK dout0_24 Vdout0_24ck142 = 1.8 time = 1430
.meas tran vdout0_24ck142 FIND v(dout0_24) AT=1430.05n

* CHECK dout0_25 Vdout0_25ck142 = 1.8 time = 1430
.meas tran vdout0_25ck142 FIND v(dout0_25) AT=1430.05n

* CHECK dout0_26 Vdout0_26ck142 = 0 time = 1430
.meas tran vdout0_26ck142 FIND v(dout0_26) AT=1430.05n

* CHECK dout0_27 Vdout0_27ck142 = 0 time = 1430
.meas tran vdout0_27ck142 FIND v(dout0_27) AT=1430.05n

* CHECK dout0_28 Vdout0_28ck142 = 1.8 time = 1430
.meas tran vdout0_28ck142 FIND v(dout0_28) AT=1430.05n

* CHECK dout0_29 Vdout0_29ck142 = 1.8 time = 1430
.meas tran vdout0_29ck142 FIND v(dout0_29) AT=1430.05n

* CHECK dout0_30 Vdout0_30ck142 = 1.8 time = 1430
.meas tran vdout0_30ck142 FIND v(dout0_30) AT=1430.05n

* CHECK dout0_31 Vdout0_31ck142 = 1.8 time = 1430
.meas tran vdout0_31ck142 FIND v(dout0_31) AT=1430.05n

* CHECK dout0_32 Vdout0_32ck142 = 0 time = 1430
.meas tran vdout0_32ck142 FIND v(dout0_32) AT=1430.05n

* CHECK dout0_0 Vdout0_0ck144 = 1.8 time = 1450
.meas tran vdout0_0ck144 FIND v(dout0_0) AT=1450.05n

* CHECK dout0_1 Vdout0_1ck144 = 0 time = 1450
.meas tran vdout0_1ck144 FIND v(dout0_1) AT=1450.05n

* CHECK dout0_2 Vdout0_2ck144 = 1.8 time = 1450
.meas tran vdout0_2ck144 FIND v(dout0_2) AT=1450.05n

* CHECK dout0_3 Vdout0_3ck144 = 1.8 time = 1450
.meas tran vdout0_3ck144 FIND v(dout0_3) AT=1450.05n

* CHECK dout0_4 Vdout0_4ck144 = 1.8 time = 1450
.meas tran vdout0_4ck144 FIND v(dout0_4) AT=1450.05n

* CHECK dout0_5 Vdout0_5ck144 = 1.8 time = 1450
.meas tran vdout0_5ck144 FIND v(dout0_5) AT=1450.05n

* CHECK dout0_6 Vdout0_6ck144 = 1.8 time = 1450
.meas tran vdout0_6ck144 FIND v(dout0_6) AT=1450.05n

* CHECK dout0_7 Vdout0_7ck144 = 0 time = 1450
.meas tran vdout0_7ck144 FIND v(dout0_7) AT=1450.05n

* CHECK dout0_8 Vdout0_8ck144 = 1.8 time = 1450
.meas tran vdout0_8ck144 FIND v(dout0_8) AT=1450.05n

* CHECK dout0_9 Vdout0_9ck144 = 1.8 time = 1450
.meas tran vdout0_9ck144 FIND v(dout0_9) AT=1450.05n

* CHECK dout0_10 Vdout0_10ck144 = 1.8 time = 1450
.meas tran vdout0_10ck144 FIND v(dout0_10) AT=1450.05n

* CHECK dout0_11 Vdout0_11ck144 = 0 time = 1450
.meas tran vdout0_11ck144 FIND v(dout0_11) AT=1450.05n

* CHECK dout0_12 Vdout0_12ck144 = 0 time = 1450
.meas tran vdout0_12ck144 FIND v(dout0_12) AT=1450.05n

* CHECK dout0_13 Vdout0_13ck144 = 1.8 time = 1450
.meas tran vdout0_13ck144 FIND v(dout0_13) AT=1450.05n

* CHECK dout0_14 Vdout0_14ck144 = 0 time = 1450
.meas tran vdout0_14ck144 FIND v(dout0_14) AT=1450.05n

* CHECK dout0_15 Vdout0_15ck144 = 1.8 time = 1450
.meas tran vdout0_15ck144 FIND v(dout0_15) AT=1450.05n

* CHECK dout0_16 Vdout0_16ck144 = 0 time = 1450
.meas tran vdout0_16ck144 FIND v(dout0_16) AT=1450.05n

* CHECK dout0_17 Vdout0_17ck144 = 1.8 time = 1450
.meas tran vdout0_17ck144 FIND v(dout0_17) AT=1450.05n

* CHECK dout0_18 Vdout0_18ck144 = 1.8 time = 1450
.meas tran vdout0_18ck144 FIND v(dout0_18) AT=1450.05n

* CHECK dout0_19 Vdout0_19ck144 = 0 time = 1450
.meas tran vdout0_19ck144 FIND v(dout0_19) AT=1450.05n

* CHECK dout0_20 Vdout0_20ck144 = 0 time = 1450
.meas tran vdout0_20ck144 FIND v(dout0_20) AT=1450.05n

* CHECK dout0_21 Vdout0_21ck144 = 0 time = 1450
.meas tran vdout0_21ck144 FIND v(dout0_21) AT=1450.05n

* CHECK dout0_22 Vdout0_22ck144 = 1.8 time = 1450
.meas tran vdout0_22ck144 FIND v(dout0_22) AT=1450.05n

* CHECK dout0_23 Vdout0_23ck144 = 1.8 time = 1450
.meas tran vdout0_23ck144 FIND v(dout0_23) AT=1450.05n

* CHECK dout0_24 Vdout0_24ck144 = 1.8 time = 1450
.meas tran vdout0_24ck144 FIND v(dout0_24) AT=1450.05n

* CHECK dout0_25 Vdout0_25ck144 = 0 time = 1450
.meas tran vdout0_25ck144 FIND v(dout0_25) AT=1450.05n

* CHECK dout0_26 Vdout0_26ck144 = 1.8 time = 1450
.meas tran vdout0_26ck144 FIND v(dout0_26) AT=1450.05n

* CHECK dout0_27 Vdout0_27ck144 = 0 time = 1450
.meas tran vdout0_27ck144 FIND v(dout0_27) AT=1450.05n

* CHECK dout0_28 Vdout0_28ck144 = 0 time = 1450
.meas tran vdout0_28ck144 FIND v(dout0_28) AT=1450.05n

* CHECK dout0_29 Vdout0_29ck144 = 1.8 time = 1450
.meas tran vdout0_29ck144 FIND v(dout0_29) AT=1450.05n

* CHECK dout0_30 Vdout0_30ck144 = 1.8 time = 1450
.meas tran vdout0_30ck144 FIND v(dout0_30) AT=1450.05n

* CHECK dout0_31 Vdout0_31ck144 = 1.8 time = 1450
.meas tran vdout0_31ck144 FIND v(dout0_31) AT=1450.05n

* CHECK dout0_32 Vdout0_32ck144 = 0 time = 1450
.meas tran vdout0_32ck144 FIND v(dout0_32) AT=1450.05n

* CHECK dout0_0 Vdout0_0ck149 = 1.8 time = 1500
.meas tran vdout0_0ck149 FIND v(dout0_0) AT=1500.05n

* CHECK dout0_1 Vdout0_1ck149 = 1.8 time = 1500
.meas tran vdout0_1ck149 FIND v(dout0_1) AT=1500.05n

* CHECK dout0_2 Vdout0_2ck149 = 0 time = 1500
.meas tran vdout0_2ck149 FIND v(dout0_2) AT=1500.05n

* CHECK dout0_3 Vdout0_3ck149 = 1.8 time = 1500
.meas tran vdout0_3ck149 FIND v(dout0_3) AT=1500.05n

* CHECK dout0_4 Vdout0_4ck149 = 1.8 time = 1500
.meas tran vdout0_4ck149 FIND v(dout0_4) AT=1500.05n

* CHECK dout0_5 Vdout0_5ck149 = 0 time = 1500
.meas tran vdout0_5ck149 FIND v(dout0_5) AT=1500.05n

* CHECK dout0_6 Vdout0_6ck149 = 1.8 time = 1500
.meas tran vdout0_6ck149 FIND v(dout0_6) AT=1500.05n

* CHECK dout0_7 Vdout0_7ck149 = 1.8 time = 1500
.meas tran vdout0_7ck149 FIND v(dout0_7) AT=1500.05n

* CHECK dout0_8 Vdout0_8ck149 = 1.8 time = 1500
.meas tran vdout0_8ck149 FIND v(dout0_8) AT=1500.05n

* CHECK dout0_9 Vdout0_9ck149 = 0 time = 1500
.meas tran vdout0_9ck149 FIND v(dout0_9) AT=1500.05n

* CHECK dout0_10 Vdout0_10ck149 = 1.8 time = 1500
.meas tran vdout0_10ck149 FIND v(dout0_10) AT=1500.05n

* CHECK dout0_11 Vdout0_11ck149 = 0 time = 1500
.meas tran vdout0_11ck149 FIND v(dout0_11) AT=1500.05n

* CHECK dout0_12 Vdout0_12ck149 = 1.8 time = 1500
.meas tran vdout0_12ck149 FIND v(dout0_12) AT=1500.05n

* CHECK dout0_13 Vdout0_13ck149 = 0 time = 1500
.meas tran vdout0_13ck149 FIND v(dout0_13) AT=1500.05n

* CHECK dout0_14 Vdout0_14ck149 = 1.8 time = 1500
.meas tran vdout0_14ck149 FIND v(dout0_14) AT=1500.05n

* CHECK dout0_15 Vdout0_15ck149 = 0 time = 1500
.meas tran vdout0_15ck149 FIND v(dout0_15) AT=1500.05n

* CHECK dout0_16 Vdout0_16ck149 = 0 time = 1500
.meas tran vdout0_16ck149 FIND v(dout0_16) AT=1500.05n

* CHECK dout0_17 Vdout0_17ck149 = 0 time = 1500
.meas tran vdout0_17ck149 FIND v(dout0_17) AT=1500.05n

* CHECK dout0_18 Vdout0_18ck149 = 1.8 time = 1500
.meas tran vdout0_18ck149 FIND v(dout0_18) AT=1500.05n

* CHECK dout0_19 Vdout0_19ck149 = 0 time = 1500
.meas tran vdout0_19ck149 FIND v(dout0_19) AT=1500.05n

* CHECK dout0_20 Vdout0_20ck149 = 0 time = 1500
.meas tran vdout0_20ck149 FIND v(dout0_20) AT=1500.05n

* CHECK dout0_21 Vdout0_21ck149 = 1.8 time = 1500
.meas tran vdout0_21ck149 FIND v(dout0_21) AT=1500.05n

* CHECK dout0_22 Vdout0_22ck149 = 1.8 time = 1500
.meas tran vdout0_22ck149 FIND v(dout0_22) AT=1500.05n

* CHECK dout0_23 Vdout0_23ck149 = 0 time = 1500
.meas tran vdout0_23ck149 FIND v(dout0_23) AT=1500.05n

* CHECK dout0_24 Vdout0_24ck149 = 0 time = 1500
.meas tran vdout0_24ck149 FIND v(dout0_24) AT=1500.05n

* CHECK dout0_25 Vdout0_25ck149 = 0 time = 1500
.meas tran vdout0_25ck149 FIND v(dout0_25) AT=1500.05n

* CHECK dout0_26 Vdout0_26ck149 = 1.8 time = 1500
.meas tran vdout0_26ck149 FIND v(dout0_26) AT=1500.05n

* CHECK dout0_27 Vdout0_27ck149 = 0 time = 1500
.meas tran vdout0_27ck149 FIND v(dout0_27) AT=1500.05n

* CHECK dout0_28 Vdout0_28ck149 = 0 time = 1500
.meas tran vdout0_28ck149 FIND v(dout0_28) AT=1500.05n

* CHECK dout0_29 Vdout0_29ck149 = 1.8 time = 1500
.meas tran vdout0_29ck149 FIND v(dout0_29) AT=1500.05n

* CHECK dout0_30 Vdout0_30ck149 = 0 time = 1500
.meas tran vdout0_30ck149 FIND v(dout0_30) AT=1500.05n

* CHECK dout0_31 Vdout0_31ck149 = 0 time = 1500
.meas tran vdout0_31ck149 FIND v(dout0_31) AT=1500.05n

* CHECK dout0_32 Vdout0_32ck149 = 0 time = 1500
.meas tran vdout0_32ck149 FIND v(dout0_32) AT=1500.05n

* CHECK dout0_0 Vdout0_0ck150 = 0 time = 1510
.meas tran vdout0_0ck150 FIND v(dout0_0) AT=1510.05n

* CHECK dout0_1 Vdout0_1ck150 = 0 time = 1510
.meas tran vdout0_1ck150 FIND v(dout0_1) AT=1510.05n

* CHECK dout0_2 Vdout0_2ck150 = 0 time = 1510
.meas tran vdout0_2ck150 FIND v(dout0_2) AT=1510.05n

* CHECK dout0_3 Vdout0_3ck150 = 0 time = 1510
.meas tran vdout0_3ck150 FIND v(dout0_3) AT=1510.05n

* CHECK dout0_4 Vdout0_4ck150 = 1.8 time = 1510
.meas tran vdout0_4ck150 FIND v(dout0_4) AT=1510.05n

* CHECK dout0_5 Vdout0_5ck150 = 1.8 time = 1510
.meas tran vdout0_5ck150 FIND v(dout0_5) AT=1510.05n

* CHECK dout0_6 Vdout0_6ck150 = 1.8 time = 1510
.meas tran vdout0_6ck150 FIND v(dout0_6) AT=1510.05n

* CHECK dout0_7 Vdout0_7ck150 = 1.8 time = 1510
.meas tran vdout0_7ck150 FIND v(dout0_7) AT=1510.05n

* CHECK dout0_8 Vdout0_8ck150 = 1.8 time = 1510
.meas tran vdout0_8ck150 FIND v(dout0_8) AT=1510.05n

* CHECK dout0_9 Vdout0_9ck150 = 0 time = 1510
.meas tran vdout0_9ck150 FIND v(dout0_9) AT=1510.05n

* CHECK dout0_10 Vdout0_10ck150 = 0 time = 1510
.meas tran vdout0_10ck150 FIND v(dout0_10) AT=1510.05n

* CHECK dout0_11 Vdout0_11ck150 = 1.8 time = 1510
.meas tran vdout0_11ck150 FIND v(dout0_11) AT=1510.05n

* CHECK dout0_12 Vdout0_12ck150 = 0 time = 1510
.meas tran vdout0_12ck150 FIND v(dout0_12) AT=1510.05n

* CHECK dout0_13 Vdout0_13ck150 = 1.8 time = 1510
.meas tran vdout0_13ck150 FIND v(dout0_13) AT=1510.05n

* CHECK dout0_14 Vdout0_14ck150 = 0 time = 1510
.meas tran vdout0_14ck150 FIND v(dout0_14) AT=1510.05n

* CHECK dout0_15 Vdout0_15ck150 = 1.8 time = 1510
.meas tran vdout0_15ck150 FIND v(dout0_15) AT=1510.05n

* CHECK dout0_16 Vdout0_16ck150 = 1.8 time = 1510
.meas tran vdout0_16ck150 FIND v(dout0_16) AT=1510.05n

* CHECK dout0_17 Vdout0_17ck150 = 1.8 time = 1510
.meas tran vdout0_17ck150 FIND v(dout0_17) AT=1510.05n

* CHECK dout0_18 Vdout0_18ck150 = 1.8 time = 1510
.meas tran vdout0_18ck150 FIND v(dout0_18) AT=1510.05n

* CHECK dout0_19 Vdout0_19ck150 = 1.8 time = 1510
.meas tran vdout0_19ck150 FIND v(dout0_19) AT=1510.05n

* CHECK dout0_20 Vdout0_20ck150 = 1.8 time = 1510
.meas tran vdout0_20ck150 FIND v(dout0_20) AT=1510.05n

* CHECK dout0_21 Vdout0_21ck150 = 1.8 time = 1510
.meas tran vdout0_21ck150 FIND v(dout0_21) AT=1510.05n

* CHECK dout0_22 Vdout0_22ck150 = 1.8 time = 1510
.meas tran vdout0_22ck150 FIND v(dout0_22) AT=1510.05n

* CHECK dout0_23 Vdout0_23ck150 = 0 time = 1510
.meas tran vdout0_23ck150 FIND v(dout0_23) AT=1510.05n

* CHECK dout0_24 Vdout0_24ck150 = 0 time = 1510
.meas tran vdout0_24ck150 FIND v(dout0_24) AT=1510.05n

* CHECK dout0_25 Vdout0_25ck150 = 1.8 time = 1510
.meas tran vdout0_25ck150 FIND v(dout0_25) AT=1510.05n

* CHECK dout0_26 Vdout0_26ck150 = 0 time = 1510
.meas tran vdout0_26ck150 FIND v(dout0_26) AT=1510.05n

* CHECK dout0_27 Vdout0_27ck150 = 1.8 time = 1510
.meas tran vdout0_27ck150 FIND v(dout0_27) AT=1510.05n

* CHECK dout0_28 Vdout0_28ck150 = 0 time = 1510
.meas tran vdout0_28ck150 FIND v(dout0_28) AT=1510.05n

* CHECK dout0_29 Vdout0_29ck150 = 1.8 time = 1510
.meas tran vdout0_29ck150 FIND v(dout0_29) AT=1510.05n

* CHECK dout0_30 Vdout0_30ck150 = 1.8 time = 1510
.meas tran vdout0_30ck150 FIND v(dout0_30) AT=1510.05n

* CHECK dout0_31 Vdout0_31ck150 = 0 time = 1510
.meas tran vdout0_31ck150 FIND v(dout0_31) AT=1510.05n

* CHECK dout0_32 Vdout0_32ck150 = 0 time = 1510
.meas tran vdout0_32ck150 FIND v(dout0_32) AT=1510.05n

* CHECK dout0_0 Vdout0_0ck154 = 1.8 time = 1550
.meas tran vdout0_0ck154 FIND v(dout0_0) AT=1550.05n

* CHECK dout0_1 Vdout0_1ck154 = 1.8 time = 1550
.meas tran vdout0_1ck154 FIND v(dout0_1) AT=1550.05n

* CHECK dout0_2 Vdout0_2ck154 = 1.8 time = 1550
.meas tran vdout0_2ck154 FIND v(dout0_2) AT=1550.05n

* CHECK dout0_3 Vdout0_3ck154 = 0 time = 1550
.meas tran vdout0_3ck154 FIND v(dout0_3) AT=1550.05n

* CHECK dout0_4 Vdout0_4ck154 = 0 time = 1550
.meas tran vdout0_4ck154 FIND v(dout0_4) AT=1550.05n

* CHECK dout0_5 Vdout0_5ck154 = 1.8 time = 1550
.meas tran vdout0_5ck154 FIND v(dout0_5) AT=1550.05n

* CHECK dout0_6 Vdout0_6ck154 = 0 time = 1550
.meas tran vdout0_6ck154 FIND v(dout0_6) AT=1550.05n

* CHECK dout0_7 Vdout0_7ck154 = 1.8 time = 1550
.meas tran vdout0_7ck154 FIND v(dout0_7) AT=1550.05n

* CHECK dout0_8 Vdout0_8ck154 = 1.8 time = 1550
.meas tran vdout0_8ck154 FIND v(dout0_8) AT=1550.05n

* CHECK dout0_9 Vdout0_9ck154 = 1.8 time = 1550
.meas tran vdout0_9ck154 FIND v(dout0_9) AT=1550.05n

* CHECK dout0_10 Vdout0_10ck154 = 0 time = 1550
.meas tran vdout0_10ck154 FIND v(dout0_10) AT=1550.05n

* CHECK dout0_11 Vdout0_11ck154 = 1.8 time = 1550
.meas tran vdout0_11ck154 FIND v(dout0_11) AT=1550.05n

* CHECK dout0_12 Vdout0_12ck154 = 1.8 time = 1550
.meas tran vdout0_12ck154 FIND v(dout0_12) AT=1550.05n

* CHECK dout0_13 Vdout0_13ck154 = 0 time = 1550
.meas tran vdout0_13ck154 FIND v(dout0_13) AT=1550.05n

* CHECK dout0_14 Vdout0_14ck154 = 1.8 time = 1550
.meas tran vdout0_14ck154 FIND v(dout0_14) AT=1550.05n

* CHECK dout0_15 Vdout0_15ck154 = 1.8 time = 1550
.meas tran vdout0_15ck154 FIND v(dout0_15) AT=1550.05n

* CHECK dout0_16 Vdout0_16ck154 = 0 time = 1550
.meas tran vdout0_16ck154 FIND v(dout0_16) AT=1550.05n

* CHECK dout0_17 Vdout0_17ck154 = 0 time = 1550
.meas tran vdout0_17ck154 FIND v(dout0_17) AT=1550.05n

* CHECK dout0_18 Vdout0_18ck154 = 1.8 time = 1550
.meas tran vdout0_18ck154 FIND v(dout0_18) AT=1550.05n

* CHECK dout0_19 Vdout0_19ck154 = 0 time = 1550
.meas tran vdout0_19ck154 FIND v(dout0_19) AT=1550.05n

* CHECK dout0_20 Vdout0_20ck154 = 1.8 time = 1550
.meas tran vdout0_20ck154 FIND v(dout0_20) AT=1550.05n

* CHECK dout0_21 Vdout0_21ck154 = 0 time = 1550
.meas tran vdout0_21ck154 FIND v(dout0_21) AT=1550.05n

* CHECK dout0_22 Vdout0_22ck154 = 1.8 time = 1550
.meas tran vdout0_22ck154 FIND v(dout0_22) AT=1550.05n

* CHECK dout0_23 Vdout0_23ck154 = 0 time = 1550
.meas tran vdout0_23ck154 FIND v(dout0_23) AT=1550.05n

* CHECK dout0_24 Vdout0_24ck154 = 0 time = 1550
.meas tran vdout0_24ck154 FIND v(dout0_24) AT=1550.05n

* CHECK dout0_25 Vdout0_25ck154 = 0 time = 1550
.meas tran vdout0_25ck154 FIND v(dout0_25) AT=1550.05n

* CHECK dout0_26 Vdout0_26ck154 = 1.8 time = 1550
.meas tran vdout0_26ck154 FIND v(dout0_26) AT=1550.05n

* CHECK dout0_27 Vdout0_27ck154 = 1.8 time = 1550
.meas tran vdout0_27ck154 FIND v(dout0_27) AT=1550.05n

* CHECK dout0_28 Vdout0_28ck154 = 0 time = 1550
.meas tran vdout0_28ck154 FIND v(dout0_28) AT=1550.05n

* CHECK dout0_29 Vdout0_29ck154 = 0 time = 1550
.meas tran vdout0_29ck154 FIND v(dout0_29) AT=1550.05n

* CHECK dout0_30 Vdout0_30ck154 = 0 time = 1550
.meas tran vdout0_30ck154 FIND v(dout0_30) AT=1550.05n

* CHECK dout0_31 Vdout0_31ck154 = 0 time = 1550
.meas tran vdout0_31ck154 FIND v(dout0_31) AT=1550.05n

* CHECK dout0_32 Vdout0_32ck154 = 0 time = 1550
.meas tran vdout0_32ck154 FIND v(dout0_32) AT=1550.05n

* CHECK dout0_0 Vdout0_0ck156 = 0 time = 1570
.meas tran vdout0_0ck156 FIND v(dout0_0) AT=1570.05n

* CHECK dout0_1 Vdout0_1ck156 = 0 time = 1570
.meas tran vdout0_1ck156 FIND v(dout0_1) AT=1570.05n

* CHECK dout0_2 Vdout0_2ck156 = 0 time = 1570
.meas tran vdout0_2ck156 FIND v(dout0_2) AT=1570.05n

* CHECK dout0_3 Vdout0_3ck156 = 0 time = 1570
.meas tran vdout0_3ck156 FIND v(dout0_3) AT=1570.05n

* CHECK dout0_4 Vdout0_4ck156 = 1.8 time = 1570
.meas tran vdout0_4ck156 FIND v(dout0_4) AT=1570.05n

* CHECK dout0_5 Vdout0_5ck156 = 1.8 time = 1570
.meas tran vdout0_5ck156 FIND v(dout0_5) AT=1570.05n

* CHECK dout0_6 Vdout0_6ck156 = 1.8 time = 1570
.meas tran vdout0_6ck156 FIND v(dout0_6) AT=1570.05n

* CHECK dout0_7 Vdout0_7ck156 = 1.8 time = 1570
.meas tran vdout0_7ck156 FIND v(dout0_7) AT=1570.05n

* CHECK dout0_8 Vdout0_8ck156 = 1.8 time = 1570
.meas tran vdout0_8ck156 FIND v(dout0_8) AT=1570.05n

* CHECK dout0_9 Vdout0_9ck156 = 0 time = 1570
.meas tran vdout0_9ck156 FIND v(dout0_9) AT=1570.05n

* CHECK dout0_10 Vdout0_10ck156 = 0 time = 1570
.meas tran vdout0_10ck156 FIND v(dout0_10) AT=1570.05n

* CHECK dout0_11 Vdout0_11ck156 = 1.8 time = 1570
.meas tran vdout0_11ck156 FIND v(dout0_11) AT=1570.05n

* CHECK dout0_12 Vdout0_12ck156 = 0 time = 1570
.meas tran vdout0_12ck156 FIND v(dout0_12) AT=1570.05n

* CHECK dout0_13 Vdout0_13ck156 = 1.8 time = 1570
.meas tran vdout0_13ck156 FIND v(dout0_13) AT=1570.05n

* CHECK dout0_14 Vdout0_14ck156 = 0 time = 1570
.meas tran vdout0_14ck156 FIND v(dout0_14) AT=1570.05n

* CHECK dout0_15 Vdout0_15ck156 = 1.8 time = 1570
.meas tran vdout0_15ck156 FIND v(dout0_15) AT=1570.05n

* CHECK dout0_16 Vdout0_16ck156 = 1.8 time = 1570
.meas tran vdout0_16ck156 FIND v(dout0_16) AT=1570.05n

* CHECK dout0_17 Vdout0_17ck156 = 1.8 time = 1570
.meas tran vdout0_17ck156 FIND v(dout0_17) AT=1570.05n

* CHECK dout0_18 Vdout0_18ck156 = 1.8 time = 1570
.meas tran vdout0_18ck156 FIND v(dout0_18) AT=1570.05n

* CHECK dout0_19 Vdout0_19ck156 = 1.8 time = 1570
.meas tran vdout0_19ck156 FIND v(dout0_19) AT=1570.05n

* CHECK dout0_20 Vdout0_20ck156 = 1.8 time = 1570
.meas tran vdout0_20ck156 FIND v(dout0_20) AT=1570.05n

* CHECK dout0_21 Vdout0_21ck156 = 1.8 time = 1570
.meas tran vdout0_21ck156 FIND v(dout0_21) AT=1570.05n

* CHECK dout0_22 Vdout0_22ck156 = 1.8 time = 1570
.meas tran vdout0_22ck156 FIND v(dout0_22) AT=1570.05n

* CHECK dout0_23 Vdout0_23ck156 = 0 time = 1570
.meas tran vdout0_23ck156 FIND v(dout0_23) AT=1570.05n

* CHECK dout0_24 Vdout0_24ck156 = 0 time = 1570
.meas tran vdout0_24ck156 FIND v(dout0_24) AT=1570.05n

* CHECK dout0_25 Vdout0_25ck156 = 1.8 time = 1570
.meas tran vdout0_25ck156 FIND v(dout0_25) AT=1570.05n

* CHECK dout0_26 Vdout0_26ck156 = 0 time = 1570
.meas tran vdout0_26ck156 FIND v(dout0_26) AT=1570.05n

* CHECK dout0_27 Vdout0_27ck156 = 1.8 time = 1570
.meas tran vdout0_27ck156 FIND v(dout0_27) AT=1570.05n

* CHECK dout0_28 Vdout0_28ck156 = 0 time = 1570
.meas tran vdout0_28ck156 FIND v(dout0_28) AT=1570.05n

* CHECK dout0_29 Vdout0_29ck156 = 1.8 time = 1570
.meas tran vdout0_29ck156 FIND v(dout0_29) AT=1570.05n

* CHECK dout0_30 Vdout0_30ck156 = 1.8 time = 1570
.meas tran vdout0_30ck156 FIND v(dout0_30) AT=1570.05n

* CHECK dout0_31 Vdout0_31ck156 = 0 time = 1570
.meas tran vdout0_31ck156 FIND v(dout0_31) AT=1570.05n

* CHECK dout0_32 Vdout0_32ck156 = 0 time = 1570
.meas tran vdout0_32ck156 FIND v(dout0_32) AT=1570.05n

* CHECK dout0_0 Vdout0_0ck159 = 0 time = 1600
.meas tran vdout0_0ck159 FIND v(dout0_0) AT=1600.05n

* CHECK dout0_1 Vdout0_1ck159 = 0 time = 1600
.meas tran vdout0_1ck159 FIND v(dout0_1) AT=1600.05n

* CHECK dout0_2 Vdout0_2ck159 = 1.8 time = 1600
.meas tran vdout0_2ck159 FIND v(dout0_2) AT=1600.05n

* CHECK dout0_3 Vdout0_3ck159 = 0 time = 1600
.meas tran vdout0_3ck159 FIND v(dout0_3) AT=1600.05n

* CHECK dout0_4 Vdout0_4ck159 = 1.8 time = 1600
.meas tran vdout0_4ck159 FIND v(dout0_4) AT=1600.05n

* CHECK dout0_5 Vdout0_5ck159 = 0 time = 1600
.meas tran vdout0_5ck159 FIND v(dout0_5) AT=1600.05n

* CHECK dout0_6 Vdout0_6ck159 = 0 time = 1600
.meas tran vdout0_6ck159 FIND v(dout0_6) AT=1600.05n

* CHECK dout0_7 Vdout0_7ck159 = 0 time = 1600
.meas tran vdout0_7ck159 FIND v(dout0_7) AT=1600.05n

* CHECK dout0_8 Vdout0_8ck159 = 1.8 time = 1600
.meas tran vdout0_8ck159 FIND v(dout0_8) AT=1600.05n

* CHECK dout0_9 Vdout0_9ck159 = 1.8 time = 1600
.meas tran vdout0_9ck159 FIND v(dout0_9) AT=1600.05n

* CHECK dout0_10 Vdout0_10ck159 = 0 time = 1600
.meas tran vdout0_10ck159 FIND v(dout0_10) AT=1600.05n

* CHECK dout0_11 Vdout0_11ck159 = 1.8 time = 1600
.meas tran vdout0_11ck159 FIND v(dout0_11) AT=1600.05n

* CHECK dout0_12 Vdout0_12ck159 = 0 time = 1600
.meas tran vdout0_12ck159 FIND v(dout0_12) AT=1600.05n

* CHECK dout0_13 Vdout0_13ck159 = 0 time = 1600
.meas tran vdout0_13ck159 FIND v(dout0_13) AT=1600.05n

* CHECK dout0_14 Vdout0_14ck159 = 0 time = 1600
.meas tran vdout0_14ck159 FIND v(dout0_14) AT=1600.05n

* CHECK dout0_15 Vdout0_15ck159 = 0 time = 1600
.meas tran vdout0_15ck159 FIND v(dout0_15) AT=1600.05n

* CHECK dout0_16 Vdout0_16ck159 = 1.8 time = 1600
.meas tran vdout0_16ck159 FIND v(dout0_16) AT=1600.05n

* CHECK dout0_17 Vdout0_17ck159 = 1.8 time = 1600
.meas tran vdout0_17ck159 FIND v(dout0_17) AT=1600.05n

* CHECK dout0_18 Vdout0_18ck159 = 1.8 time = 1600
.meas tran vdout0_18ck159 FIND v(dout0_18) AT=1600.05n

* CHECK dout0_19 Vdout0_19ck159 = 0 time = 1600
.meas tran vdout0_19ck159 FIND v(dout0_19) AT=1600.05n

* CHECK dout0_20 Vdout0_20ck159 = 1.8 time = 1600
.meas tran vdout0_20ck159 FIND v(dout0_20) AT=1600.05n

* CHECK dout0_21 Vdout0_21ck159 = 1.8 time = 1600
.meas tran vdout0_21ck159 FIND v(dout0_21) AT=1600.05n

* CHECK dout0_22 Vdout0_22ck159 = 1.8 time = 1600
.meas tran vdout0_22ck159 FIND v(dout0_22) AT=1600.05n

* CHECK dout0_23 Vdout0_23ck159 = 1.8 time = 1600
.meas tran vdout0_23ck159 FIND v(dout0_23) AT=1600.05n

* CHECK dout0_24 Vdout0_24ck159 = 1.8 time = 1600
.meas tran vdout0_24ck159 FIND v(dout0_24) AT=1600.05n

* CHECK dout0_25 Vdout0_25ck159 = 0 time = 1600
.meas tran vdout0_25ck159 FIND v(dout0_25) AT=1600.05n

* CHECK dout0_26 Vdout0_26ck159 = 0 time = 1600
.meas tran vdout0_26ck159 FIND v(dout0_26) AT=1600.05n

* CHECK dout0_27 Vdout0_27ck159 = 1.8 time = 1600
.meas tran vdout0_27ck159 FIND v(dout0_27) AT=1600.05n

* CHECK dout0_28 Vdout0_28ck159 = 0 time = 1600
.meas tran vdout0_28ck159 FIND v(dout0_28) AT=1600.05n

* CHECK dout0_29 Vdout0_29ck159 = 1.8 time = 1600
.meas tran vdout0_29ck159 FIND v(dout0_29) AT=1600.05n

* CHECK dout0_30 Vdout0_30ck159 = 0 time = 1600
.meas tran vdout0_30ck159 FIND v(dout0_30) AT=1600.05n

* CHECK dout0_31 Vdout0_31ck159 = 0 time = 1600
.meas tran vdout0_31ck159 FIND v(dout0_31) AT=1600.05n

* CHECK dout0_32 Vdout0_32ck159 = 0 time = 1600
.meas tran vdout0_32ck159 FIND v(dout0_32) AT=1600.05n

* CHECK dout0_0 Vdout0_0ck160 = 0 time = 1610
.meas tran vdout0_0ck160 FIND v(dout0_0) AT=1610.05n

* CHECK dout0_1 Vdout0_1ck160 = 0 time = 1610
.meas tran vdout0_1ck160 FIND v(dout0_1) AT=1610.05n

* CHECK dout0_2 Vdout0_2ck160 = 1.8 time = 1610
.meas tran vdout0_2ck160 FIND v(dout0_2) AT=1610.05n

* CHECK dout0_3 Vdout0_3ck160 = 0 time = 1610
.meas tran vdout0_3ck160 FIND v(dout0_3) AT=1610.05n

* CHECK dout0_4 Vdout0_4ck160 = 1.8 time = 1610
.meas tran vdout0_4ck160 FIND v(dout0_4) AT=1610.05n

* CHECK dout0_5 Vdout0_5ck160 = 0 time = 1610
.meas tran vdout0_5ck160 FIND v(dout0_5) AT=1610.05n

* CHECK dout0_6 Vdout0_6ck160 = 0 time = 1610
.meas tran vdout0_6ck160 FIND v(dout0_6) AT=1610.05n

* CHECK dout0_7 Vdout0_7ck160 = 0 time = 1610
.meas tran vdout0_7ck160 FIND v(dout0_7) AT=1610.05n

* CHECK dout0_8 Vdout0_8ck160 = 1.8 time = 1610
.meas tran vdout0_8ck160 FIND v(dout0_8) AT=1610.05n

* CHECK dout0_9 Vdout0_9ck160 = 1.8 time = 1610
.meas tran vdout0_9ck160 FIND v(dout0_9) AT=1610.05n

* CHECK dout0_10 Vdout0_10ck160 = 0 time = 1610
.meas tran vdout0_10ck160 FIND v(dout0_10) AT=1610.05n

* CHECK dout0_11 Vdout0_11ck160 = 1.8 time = 1610
.meas tran vdout0_11ck160 FIND v(dout0_11) AT=1610.05n

* CHECK dout0_12 Vdout0_12ck160 = 0 time = 1610
.meas tran vdout0_12ck160 FIND v(dout0_12) AT=1610.05n

* CHECK dout0_13 Vdout0_13ck160 = 0 time = 1610
.meas tran vdout0_13ck160 FIND v(dout0_13) AT=1610.05n

* CHECK dout0_14 Vdout0_14ck160 = 0 time = 1610
.meas tran vdout0_14ck160 FIND v(dout0_14) AT=1610.05n

* CHECK dout0_15 Vdout0_15ck160 = 0 time = 1610
.meas tran vdout0_15ck160 FIND v(dout0_15) AT=1610.05n

* CHECK dout0_16 Vdout0_16ck160 = 1.8 time = 1610
.meas tran vdout0_16ck160 FIND v(dout0_16) AT=1610.05n

* CHECK dout0_17 Vdout0_17ck160 = 1.8 time = 1610
.meas tran vdout0_17ck160 FIND v(dout0_17) AT=1610.05n

* CHECK dout0_18 Vdout0_18ck160 = 1.8 time = 1610
.meas tran vdout0_18ck160 FIND v(dout0_18) AT=1610.05n

* CHECK dout0_19 Vdout0_19ck160 = 0 time = 1610
.meas tran vdout0_19ck160 FIND v(dout0_19) AT=1610.05n

* CHECK dout0_20 Vdout0_20ck160 = 1.8 time = 1610
.meas tran vdout0_20ck160 FIND v(dout0_20) AT=1610.05n

* CHECK dout0_21 Vdout0_21ck160 = 1.8 time = 1610
.meas tran vdout0_21ck160 FIND v(dout0_21) AT=1610.05n

* CHECK dout0_22 Vdout0_22ck160 = 1.8 time = 1610
.meas tran vdout0_22ck160 FIND v(dout0_22) AT=1610.05n

* CHECK dout0_23 Vdout0_23ck160 = 1.8 time = 1610
.meas tran vdout0_23ck160 FIND v(dout0_23) AT=1610.05n

* CHECK dout0_24 Vdout0_24ck160 = 1.8 time = 1610
.meas tran vdout0_24ck160 FIND v(dout0_24) AT=1610.05n

* CHECK dout0_25 Vdout0_25ck160 = 0 time = 1610
.meas tran vdout0_25ck160 FIND v(dout0_25) AT=1610.05n

* CHECK dout0_26 Vdout0_26ck160 = 0 time = 1610
.meas tran vdout0_26ck160 FIND v(dout0_26) AT=1610.05n

* CHECK dout0_27 Vdout0_27ck160 = 1.8 time = 1610
.meas tran vdout0_27ck160 FIND v(dout0_27) AT=1610.05n

* CHECK dout0_28 Vdout0_28ck160 = 0 time = 1610
.meas tran vdout0_28ck160 FIND v(dout0_28) AT=1610.05n

* CHECK dout0_29 Vdout0_29ck160 = 1.8 time = 1610
.meas tran vdout0_29ck160 FIND v(dout0_29) AT=1610.05n

* CHECK dout0_30 Vdout0_30ck160 = 0 time = 1610
.meas tran vdout0_30ck160 FIND v(dout0_30) AT=1610.05n

* CHECK dout0_31 Vdout0_31ck160 = 0 time = 1610
.meas tran vdout0_31ck160 FIND v(dout0_31) AT=1610.05n

* CHECK dout0_32 Vdout0_32ck160 = 0 time = 1610
.meas tran vdout0_32ck160 FIND v(dout0_32) AT=1610.05n

* CHECK dout0_0 Vdout0_0ck161 = 0 time = 1620
.meas tran vdout0_0ck161 FIND v(dout0_0) AT=1620.05n

* CHECK dout0_1 Vdout0_1ck161 = 0 time = 1620
.meas tran vdout0_1ck161 FIND v(dout0_1) AT=1620.05n

* CHECK dout0_2 Vdout0_2ck161 = 1.8 time = 1620
.meas tran vdout0_2ck161 FIND v(dout0_2) AT=1620.05n

* CHECK dout0_3 Vdout0_3ck161 = 0 time = 1620
.meas tran vdout0_3ck161 FIND v(dout0_3) AT=1620.05n

* CHECK dout0_4 Vdout0_4ck161 = 1.8 time = 1620
.meas tran vdout0_4ck161 FIND v(dout0_4) AT=1620.05n

* CHECK dout0_5 Vdout0_5ck161 = 0 time = 1620
.meas tran vdout0_5ck161 FIND v(dout0_5) AT=1620.05n

* CHECK dout0_6 Vdout0_6ck161 = 0 time = 1620
.meas tran vdout0_6ck161 FIND v(dout0_6) AT=1620.05n

* CHECK dout0_7 Vdout0_7ck161 = 0 time = 1620
.meas tran vdout0_7ck161 FIND v(dout0_7) AT=1620.05n

* CHECK dout0_8 Vdout0_8ck161 = 1.8 time = 1620
.meas tran vdout0_8ck161 FIND v(dout0_8) AT=1620.05n

* CHECK dout0_9 Vdout0_9ck161 = 1.8 time = 1620
.meas tran vdout0_9ck161 FIND v(dout0_9) AT=1620.05n

* CHECK dout0_10 Vdout0_10ck161 = 0 time = 1620
.meas tran vdout0_10ck161 FIND v(dout0_10) AT=1620.05n

* CHECK dout0_11 Vdout0_11ck161 = 1.8 time = 1620
.meas tran vdout0_11ck161 FIND v(dout0_11) AT=1620.05n

* CHECK dout0_12 Vdout0_12ck161 = 0 time = 1620
.meas tran vdout0_12ck161 FIND v(dout0_12) AT=1620.05n

* CHECK dout0_13 Vdout0_13ck161 = 0 time = 1620
.meas tran vdout0_13ck161 FIND v(dout0_13) AT=1620.05n

* CHECK dout0_14 Vdout0_14ck161 = 0 time = 1620
.meas tran vdout0_14ck161 FIND v(dout0_14) AT=1620.05n

* CHECK dout0_15 Vdout0_15ck161 = 0 time = 1620
.meas tran vdout0_15ck161 FIND v(dout0_15) AT=1620.05n

* CHECK dout0_16 Vdout0_16ck161 = 1.8 time = 1620
.meas tran vdout0_16ck161 FIND v(dout0_16) AT=1620.05n

* CHECK dout0_17 Vdout0_17ck161 = 1.8 time = 1620
.meas tran vdout0_17ck161 FIND v(dout0_17) AT=1620.05n

* CHECK dout0_18 Vdout0_18ck161 = 1.8 time = 1620
.meas tran vdout0_18ck161 FIND v(dout0_18) AT=1620.05n

* CHECK dout0_19 Vdout0_19ck161 = 0 time = 1620
.meas tran vdout0_19ck161 FIND v(dout0_19) AT=1620.05n

* CHECK dout0_20 Vdout0_20ck161 = 1.8 time = 1620
.meas tran vdout0_20ck161 FIND v(dout0_20) AT=1620.05n

* CHECK dout0_21 Vdout0_21ck161 = 1.8 time = 1620
.meas tran vdout0_21ck161 FIND v(dout0_21) AT=1620.05n

* CHECK dout0_22 Vdout0_22ck161 = 1.8 time = 1620
.meas tran vdout0_22ck161 FIND v(dout0_22) AT=1620.05n

* CHECK dout0_23 Vdout0_23ck161 = 1.8 time = 1620
.meas tran vdout0_23ck161 FIND v(dout0_23) AT=1620.05n

* CHECK dout0_24 Vdout0_24ck161 = 1.8 time = 1620
.meas tran vdout0_24ck161 FIND v(dout0_24) AT=1620.05n

* CHECK dout0_25 Vdout0_25ck161 = 0 time = 1620
.meas tran vdout0_25ck161 FIND v(dout0_25) AT=1620.05n

* CHECK dout0_26 Vdout0_26ck161 = 0 time = 1620
.meas tran vdout0_26ck161 FIND v(dout0_26) AT=1620.05n

* CHECK dout0_27 Vdout0_27ck161 = 1.8 time = 1620
.meas tran vdout0_27ck161 FIND v(dout0_27) AT=1620.05n

* CHECK dout0_28 Vdout0_28ck161 = 0 time = 1620
.meas tran vdout0_28ck161 FIND v(dout0_28) AT=1620.05n

* CHECK dout0_29 Vdout0_29ck161 = 1.8 time = 1620
.meas tran vdout0_29ck161 FIND v(dout0_29) AT=1620.05n

* CHECK dout0_30 Vdout0_30ck161 = 0 time = 1620
.meas tran vdout0_30ck161 FIND v(dout0_30) AT=1620.05n

* CHECK dout0_31 Vdout0_31ck161 = 0 time = 1620
.meas tran vdout0_31ck161 FIND v(dout0_31) AT=1620.05n

* CHECK dout0_32 Vdout0_32ck161 = 0 time = 1620
.meas tran vdout0_32ck161 FIND v(dout0_32) AT=1620.05n

* CHECK dout0_0 Vdout0_0ck162 = 0 time = 1630
.meas tran vdout0_0ck162 FIND v(dout0_0) AT=1630.05n

* CHECK dout0_1 Vdout0_1ck162 = 0 time = 1630
.meas tran vdout0_1ck162 FIND v(dout0_1) AT=1630.05n

* CHECK dout0_2 Vdout0_2ck162 = 1.8 time = 1630
.meas tran vdout0_2ck162 FIND v(dout0_2) AT=1630.05n

* CHECK dout0_3 Vdout0_3ck162 = 0 time = 1630
.meas tran vdout0_3ck162 FIND v(dout0_3) AT=1630.05n

* CHECK dout0_4 Vdout0_4ck162 = 1.8 time = 1630
.meas tran vdout0_4ck162 FIND v(dout0_4) AT=1630.05n

* CHECK dout0_5 Vdout0_5ck162 = 0 time = 1630
.meas tran vdout0_5ck162 FIND v(dout0_5) AT=1630.05n

* CHECK dout0_6 Vdout0_6ck162 = 0 time = 1630
.meas tran vdout0_6ck162 FIND v(dout0_6) AT=1630.05n

* CHECK dout0_7 Vdout0_7ck162 = 0 time = 1630
.meas tran vdout0_7ck162 FIND v(dout0_7) AT=1630.05n

* CHECK dout0_8 Vdout0_8ck162 = 1.8 time = 1630
.meas tran vdout0_8ck162 FIND v(dout0_8) AT=1630.05n

* CHECK dout0_9 Vdout0_9ck162 = 1.8 time = 1630
.meas tran vdout0_9ck162 FIND v(dout0_9) AT=1630.05n

* CHECK dout0_10 Vdout0_10ck162 = 0 time = 1630
.meas tran vdout0_10ck162 FIND v(dout0_10) AT=1630.05n

* CHECK dout0_11 Vdout0_11ck162 = 1.8 time = 1630
.meas tran vdout0_11ck162 FIND v(dout0_11) AT=1630.05n

* CHECK dout0_12 Vdout0_12ck162 = 0 time = 1630
.meas tran vdout0_12ck162 FIND v(dout0_12) AT=1630.05n

* CHECK dout0_13 Vdout0_13ck162 = 0 time = 1630
.meas tran vdout0_13ck162 FIND v(dout0_13) AT=1630.05n

* CHECK dout0_14 Vdout0_14ck162 = 0 time = 1630
.meas tran vdout0_14ck162 FIND v(dout0_14) AT=1630.05n

* CHECK dout0_15 Vdout0_15ck162 = 0 time = 1630
.meas tran vdout0_15ck162 FIND v(dout0_15) AT=1630.05n

* CHECK dout0_16 Vdout0_16ck162 = 1.8 time = 1630
.meas tran vdout0_16ck162 FIND v(dout0_16) AT=1630.05n

* CHECK dout0_17 Vdout0_17ck162 = 1.8 time = 1630
.meas tran vdout0_17ck162 FIND v(dout0_17) AT=1630.05n

* CHECK dout0_18 Vdout0_18ck162 = 1.8 time = 1630
.meas tran vdout0_18ck162 FIND v(dout0_18) AT=1630.05n

* CHECK dout0_19 Vdout0_19ck162 = 0 time = 1630
.meas tran vdout0_19ck162 FIND v(dout0_19) AT=1630.05n

* CHECK dout0_20 Vdout0_20ck162 = 1.8 time = 1630
.meas tran vdout0_20ck162 FIND v(dout0_20) AT=1630.05n

* CHECK dout0_21 Vdout0_21ck162 = 1.8 time = 1630
.meas tran vdout0_21ck162 FIND v(dout0_21) AT=1630.05n

* CHECK dout0_22 Vdout0_22ck162 = 1.8 time = 1630
.meas tran vdout0_22ck162 FIND v(dout0_22) AT=1630.05n

* CHECK dout0_23 Vdout0_23ck162 = 1.8 time = 1630
.meas tran vdout0_23ck162 FIND v(dout0_23) AT=1630.05n

* CHECK dout0_24 Vdout0_24ck162 = 1.8 time = 1630
.meas tran vdout0_24ck162 FIND v(dout0_24) AT=1630.05n

* CHECK dout0_25 Vdout0_25ck162 = 0 time = 1630
.meas tran vdout0_25ck162 FIND v(dout0_25) AT=1630.05n

* CHECK dout0_26 Vdout0_26ck162 = 0 time = 1630
.meas tran vdout0_26ck162 FIND v(dout0_26) AT=1630.05n

* CHECK dout0_27 Vdout0_27ck162 = 1.8 time = 1630
.meas tran vdout0_27ck162 FIND v(dout0_27) AT=1630.05n

* CHECK dout0_28 Vdout0_28ck162 = 0 time = 1630
.meas tran vdout0_28ck162 FIND v(dout0_28) AT=1630.05n

* CHECK dout0_29 Vdout0_29ck162 = 1.8 time = 1630
.meas tran vdout0_29ck162 FIND v(dout0_29) AT=1630.05n

* CHECK dout0_30 Vdout0_30ck162 = 0 time = 1630
.meas tran vdout0_30ck162 FIND v(dout0_30) AT=1630.05n

* CHECK dout0_31 Vdout0_31ck162 = 0 time = 1630
.meas tran vdout0_31ck162 FIND v(dout0_31) AT=1630.05n

* CHECK dout0_32 Vdout0_32ck162 = 0 time = 1630
.meas tran vdout0_32ck162 FIND v(dout0_32) AT=1630.05n

* CHECK dout0_0 Vdout0_0ck168 = 1.8 time = 1690
.meas tran vdout0_0ck168 FIND v(dout0_0) AT=1690.05n

* CHECK dout0_1 Vdout0_1ck168 = 1.8 time = 1690
.meas tran vdout0_1ck168 FIND v(dout0_1) AT=1690.05n

* CHECK dout0_2 Vdout0_2ck168 = 1.8 time = 1690
.meas tran vdout0_2ck168 FIND v(dout0_2) AT=1690.05n

* CHECK dout0_3 Vdout0_3ck168 = 0 time = 1690
.meas tran vdout0_3ck168 FIND v(dout0_3) AT=1690.05n

* CHECK dout0_4 Vdout0_4ck168 = 0 time = 1690
.meas tran vdout0_4ck168 FIND v(dout0_4) AT=1690.05n

* CHECK dout0_5 Vdout0_5ck168 = 1.8 time = 1690
.meas tran vdout0_5ck168 FIND v(dout0_5) AT=1690.05n

* CHECK dout0_6 Vdout0_6ck168 = 0 time = 1690
.meas tran vdout0_6ck168 FIND v(dout0_6) AT=1690.05n

* CHECK dout0_7 Vdout0_7ck168 = 1.8 time = 1690
.meas tran vdout0_7ck168 FIND v(dout0_7) AT=1690.05n

* CHECK dout0_8 Vdout0_8ck168 = 1.8 time = 1690
.meas tran vdout0_8ck168 FIND v(dout0_8) AT=1690.05n

* CHECK dout0_9 Vdout0_9ck168 = 1.8 time = 1690
.meas tran vdout0_9ck168 FIND v(dout0_9) AT=1690.05n

* CHECK dout0_10 Vdout0_10ck168 = 0 time = 1690
.meas tran vdout0_10ck168 FIND v(dout0_10) AT=1690.05n

* CHECK dout0_11 Vdout0_11ck168 = 1.8 time = 1690
.meas tran vdout0_11ck168 FIND v(dout0_11) AT=1690.05n

* CHECK dout0_12 Vdout0_12ck168 = 1.8 time = 1690
.meas tran vdout0_12ck168 FIND v(dout0_12) AT=1690.05n

* CHECK dout0_13 Vdout0_13ck168 = 0 time = 1690
.meas tran vdout0_13ck168 FIND v(dout0_13) AT=1690.05n

* CHECK dout0_14 Vdout0_14ck168 = 1.8 time = 1690
.meas tran vdout0_14ck168 FIND v(dout0_14) AT=1690.05n

* CHECK dout0_15 Vdout0_15ck168 = 1.8 time = 1690
.meas tran vdout0_15ck168 FIND v(dout0_15) AT=1690.05n

* CHECK dout0_16 Vdout0_16ck168 = 0 time = 1690
.meas tran vdout0_16ck168 FIND v(dout0_16) AT=1690.05n

* CHECK dout0_17 Vdout0_17ck168 = 0 time = 1690
.meas tran vdout0_17ck168 FIND v(dout0_17) AT=1690.05n

* CHECK dout0_18 Vdout0_18ck168 = 1.8 time = 1690
.meas tran vdout0_18ck168 FIND v(dout0_18) AT=1690.05n

* CHECK dout0_19 Vdout0_19ck168 = 0 time = 1690
.meas tran vdout0_19ck168 FIND v(dout0_19) AT=1690.05n

* CHECK dout0_20 Vdout0_20ck168 = 1.8 time = 1690
.meas tran vdout0_20ck168 FIND v(dout0_20) AT=1690.05n

* CHECK dout0_21 Vdout0_21ck168 = 0 time = 1690
.meas tran vdout0_21ck168 FIND v(dout0_21) AT=1690.05n

* CHECK dout0_22 Vdout0_22ck168 = 1.8 time = 1690
.meas tran vdout0_22ck168 FIND v(dout0_22) AT=1690.05n

* CHECK dout0_23 Vdout0_23ck168 = 0 time = 1690
.meas tran vdout0_23ck168 FIND v(dout0_23) AT=1690.05n

* CHECK dout0_24 Vdout0_24ck168 = 0 time = 1690
.meas tran vdout0_24ck168 FIND v(dout0_24) AT=1690.05n

* CHECK dout0_25 Vdout0_25ck168 = 0 time = 1690
.meas tran vdout0_25ck168 FIND v(dout0_25) AT=1690.05n

* CHECK dout0_26 Vdout0_26ck168 = 1.8 time = 1690
.meas tran vdout0_26ck168 FIND v(dout0_26) AT=1690.05n

* CHECK dout0_27 Vdout0_27ck168 = 1.8 time = 1690
.meas tran vdout0_27ck168 FIND v(dout0_27) AT=1690.05n

* CHECK dout0_28 Vdout0_28ck168 = 0 time = 1690
.meas tran vdout0_28ck168 FIND v(dout0_28) AT=1690.05n

* CHECK dout0_29 Vdout0_29ck168 = 0 time = 1690
.meas tran vdout0_29ck168 FIND v(dout0_29) AT=1690.05n

* CHECK dout0_30 Vdout0_30ck168 = 0 time = 1690
.meas tran vdout0_30ck168 FIND v(dout0_30) AT=1690.05n

* CHECK dout0_31 Vdout0_31ck168 = 0 time = 1690
.meas tran vdout0_31ck168 FIND v(dout0_31) AT=1690.05n

* CHECK dout0_32 Vdout0_32ck168 = 0 time = 1690
.meas tran vdout0_32ck168 FIND v(dout0_32) AT=1690.05n

* CHECK dout0_0 Vdout0_0ck170 = 1.8 time = 1710
.meas tran vdout0_0ck170 FIND v(dout0_0) AT=1710.05n

* CHECK dout0_1 Vdout0_1ck170 = 1.8 time = 1710
.meas tran vdout0_1ck170 FIND v(dout0_1) AT=1710.05n

* CHECK dout0_2 Vdout0_2ck170 = 1.8 time = 1710
.meas tran vdout0_2ck170 FIND v(dout0_2) AT=1710.05n

* CHECK dout0_3 Vdout0_3ck170 = 0 time = 1710
.meas tran vdout0_3ck170 FIND v(dout0_3) AT=1710.05n

* CHECK dout0_4 Vdout0_4ck170 = 0 time = 1710
.meas tran vdout0_4ck170 FIND v(dout0_4) AT=1710.05n

* CHECK dout0_5 Vdout0_5ck170 = 1.8 time = 1710
.meas tran vdout0_5ck170 FIND v(dout0_5) AT=1710.05n

* CHECK dout0_6 Vdout0_6ck170 = 1.8 time = 1710
.meas tran vdout0_6ck170 FIND v(dout0_6) AT=1710.05n

* CHECK dout0_7 Vdout0_7ck170 = 0 time = 1710
.meas tran vdout0_7ck170 FIND v(dout0_7) AT=1710.05n

* CHECK dout0_8 Vdout0_8ck170 = 0 time = 1710
.meas tran vdout0_8ck170 FIND v(dout0_8) AT=1710.05n

* CHECK dout0_9 Vdout0_9ck170 = 0 time = 1710
.meas tran vdout0_9ck170 FIND v(dout0_9) AT=1710.05n

* CHECK dout0_10 Vdout0_10ck170 = 0 time = 1710
.meas tran vdout0_10ck170 FIND v(dout0_10) AT=1710.05n

* CHECK dout0_11 Vdout0_11ck170 = 0 time = 1710
.meas tran vdout0_11ck170 FIND v(dout0_11) AT=1710.05n

* CHECK dout0_12 Vdout0_12ck170 = 0 time = 1710
.meas tran vdout0_12ck170 FIND v(dout0_12) AT=1710.05n

* CHECK dout0_13 Vdout0_13ck170 = 0 time = 1710
.meas tran vdout0_13ck170 FIND v(dout0_13) AT=1710.05n

* CHECK dout0_14 Vdout0_14ck170 = 0 time = 1710
.meas tran vdout0_14ck170 FIND v(dout0_14) AT=1710.05n

* CHECK dout0_15 Vdout0_15ck170 = 1.8 time = 1710
.meas tran vdout0_15ck170 FIND v(dout0_15) AT=1710.05n

* CHECK dout0_16 Vdout0_16ck170 = 0 time = 1710
.meas tran vdout0_16ck170 FIND v(dout0_16) AT=1710.05n

* CHECK dout0_17 Vdout0_17ck170 = 0 time = 1710
.meas tran vdout0_17ck170 FIND v(dout0_17) AT=1710.05n

* CHECK dout0_18 Vdout0_18ck170 = 0 time = 1710
.meas tran vdout0_18ck170 FIND v(dout0_18) AT=1710.05n

* CHECK dout0_19 Vdout0_19ck170 = 0 time = 1710
.meas tran vdout0_19ck170 FIND v(dout0_19) AT=1710.05n

* CHECK dout0_20 Vdout0_20ck170 = 1.8 time = 1710
.meas tran vdout0_20ck170 FIND v(dout0_20) AT=1710.05n

* CHECK dout0_21 Vdout0_21ck170 = 1.8 time = 1710
.meas tran vdout0_21ck170 FIND v(dout0_21) AT=1710.05n

* CHECK dout0_22 Vdout0_22ck170 = 1.8 time = 1710
.meas tran vdout0_22ck170 FIND v(dout0_22) AT=1710.05n

* CHECK dout0_23 Vdout0_23ck170 = 0 time = 1710
.meas tran vdout0_23ck170 FIND v(dout0_23) AT=1710.05n

* CHECK dout0_24 Vdout0_24ck170 = 1.8 time = 1710
.meas tran vdout0_24ck170 FIND v(dout0_24) AT=1710.05n

* CHECK dout0_25 Vdout0_25ck170 = 1.8 time = 1710
.meas tran vdout0_25ck170 FIND v(dout0_25) AT=1710.05n

* CHECK dout0_26 Vdout0_26ck170 = 0 time = 1710
.meas tran vdout0_26ck170 FIND v(dout0_26) AT=1710.05n

* CHECK dout0_27 Vdout0_27ck170 = 0 time = 1710
.meas tran vdout0_27ck170 FIND v(dout0_27) AT=1710.05n

* CHECK dout0_28 Vdout0_28ck170 = 0 time = 1710
.meas tran vdout0_28ck170 FIND v(dout0_28) AT=1710.05n

* CHECK dout0_29 Vdout0_29ck170 = 1.8 time = 1710
.meas tran vdout0_29ck170 FIND v(dout0_29) AT=1710.05n

* CHECK dout0_30 Vdout0_30ck170 = 1.8 time = 1710
.meas tran vdout0_30ck170 FIND v(dout0_30) AT=1710.05n

* CHECK dout0_31 Vdout0_31ck170 = 0 time = 1710
.meas tran vdout0_31ck170 FIND v(dout0_31) AT=1710.05n

* CHECK dout0_32 Vdout0_32ck170 = 0 time = 1710
.meas tran vdout0_32ck170 FIND v(dout0_32) AT=1710.05n

* CHECK dout0_0 Vdout0_0ck175 = 0 time = 1760
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=1760.05n

* CHECK dout0_1 Vdout0_1ck175 = 0 time = 1760
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=1760.05n

* CHECK dout0_2 Vdout0_2ck175 = 1.8 time = 1760
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=1760.05n

* CHECK dout0_3 Vdout0_3ck175 = 1.8 time = 1760
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=1760.05n

* CHECK dout0_4 Vdout0_4ck175 = 1.8 time = 1760
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=1760.05n

* CHECK dout0_5 Vdout0_5ck175 = 1.8 time = 1760
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=1760.05n

* CHECK dout0_6 Vdout0_6ck175 = 0 time = 1760
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=1760.05n

* CHECK dout0_7 Vdout0_7ck175 = 1.8 time = 1760
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=1760.05n

* CHECK dout0_8 Vdout0_8ck175 = 0 time = 1760
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=1760.05n

* CHECK dout0_9 Vdout0_9ck175 = 1.8 time = 1760
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=1760.05n

* CHECK dout0_10 Vdout0_10ck175 = 1.8 time = 1760
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=1760.05n

* CHECK dout0_11 Vdout0_11ck175 = 1.8 time = 1760
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=1760.05n

* CHECK dout0_12 Vdout0_12ck175 = 1.8 time = 1760
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=1760.05n

* CHECK dout0_13 Vdout0_13ck175 = 1.8 time = 1760
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=1760.05n

* CHECK dout0_14 Vdout0_14ck175 = 0 time = 1760
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=1760.05n

* CHECK dout0_15 Vdout0_15ck175 = 0 time = 1760
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=1760.05n

* CHECK dout0_16 Vdout0_16ck175 = 0 time = 1760
.meas tran vdout0_16ck175 FIND v(dout0_16) AT=1760.05n

* CHECK dout0_17 Vdout0_17ck175 = 1.8 time = 1760
.meas tran vdout0_17ck175 FIND v(dout0_17) AT=1760.05n

* CHECK dout0_18 Vdout0_18ck175 = 1.8 time = 1760
.meas tran vdout0_18ck175 FIND v(dout0_18) AT=1760.05n

* CHECK dout0_19 Vdout0_19ck175 = 1.8 time = 1760
.meas tran vdout0_19ck175 FIND v(dout0_19) AT=1760.05n

* CHECK dout0_20 Vdout0_20ck175 = 1.8 time = 1760
.meas tran vdout0_20ck175 FIND v(dout0_20) AT=1760.05n

* CHECK dout0_21 Vdout0_21ck175 = 1.8 time = 1760
.meas tran vdout0_21ck175 FIND v(dout0_21) AT=1760.05n

* CHECK dout0_22 Vdout0_22ck175 = 1.8 time = 1760
.meas tran vdout0_22ck175 FIND v(dout0_22) AT=1760.05n

* CHECK dout0_23 Vdout0_23ck175 = 1.8 time = 1760
.meas tran vdout0_23ck175 FIND v(dout0_23) AT=1760.05n

* CHECK dout0_24 Vdout0_24ck175 = 0 time = 1760
.meas tran vdout0_24ck175 FIND v(dout0_24) AT=1760.05n

* CHECK dout0_25 Vdout0_25ck175 = 0 time = 1760
.meas tran vdout0_25ck175 FIND v(dout0_25) AT=1760.05n

* CHECK dout0_26 Vdout0_26ck175 = 1.8 time = 1760
.meas tran vdout0_26ck175 FIND v(dout0_26) AT=1760.05n

* CHECK dout0_27 Vdout0_27ck175 = 1.8 time = 1760
.meas tran vdout0_27ck175 FIND v(dout0_27) AT=1760.05n

* CHECK dout0_28 Vdout0_28ck175 = 1.8 time = 1760
.meas tran vdout0_28ck175 FIND v(dout0_28) AT=1760.05n

* CHECK dout0_29 Vdout0_29ck175 = 0 time = 1760
.meas tran vdout0_29ck175 FIND v(dout0_29) AT=1760.05n

* CHECK dout0_30 Vdout0_30ck175 = 0 time = 1760
.meas tran vdout0_30ck175 FIND v(dout0_30) AT=1760.05n

* CHECK dout0_31 Vdout0_31ck175 = 0 time = 1760
.meas tran vdout0_31ck175 FIND v(dout0_31) AT=1760.05n

* CHECK dout0_32 Vdout0_32ck175 = 0 time = 1760
.meas tran vdout0_32ck175 FIND v(dout0_32) AT=1760.05n

* CHECK dout0_0 Vdout0_0ck179 = 1.8 time = 1800
.meas tran vdout0_0ck179 FIND v(dout0_0) AT=1800.05n

* CHECK dout0_1 Vdout0_1ck179 = 1.8 time = 1800
.meas tran vdout0_1ck179 FIND v(dout0_1) AT=1800.05n

* CHECK dout0_2 Vdout0_2ck179 = 0 time = 1800
.meas tran vdout0_2ck179 FIND v(dout0_2) AT=1800.05n

* CHECK dout0_3 Vdout0_3ck179 = 1.8 time = 1800
.meas tran vdout0_3ck179 FIND v(dout0_3) AT=1800.05n

* CHECK dout0_4 Vdout0_4ck179 = 1.8 time = 1800
.meas tran vdout0_4ck179 FIND v(dout0_4) AT=1800.05n

* CHECK dout0_5 Vdout0_5ck179 = 1.8 time = 1800
.meas tran vdout0_5ck179 FIND v(dout0_5) AT=1800.05n

* CHECK dout0_6 Vdout0_6ck179 = 1.8 time = 1800
.meas tran vdout0_6ck179 FIND v(dout0_6) AT=1800.05n

* CHECK dout0_7 Vdout0_7ck179 = 0 time = 1800
.meas tran vdout0_7ck179 FIND v(dout0_7) AT=1800.05n

* CHECK dout0_8 Vdout0_8ck179 = 1.8 time = 1800
.meas tran vdout0_8ck179 FIND v(dout0_8) AT=1800.05n

* CHECK dout0_9 Vdout0_9ck179 = 1.8 time = 1800
.meas tran vdout0_9ck179 FIND v(dout0_9) AT=1800.05n

* CHECK dout0_10 Vdout0_10ck179 = 1.8 time = 1800
.meas tran vdout0_10ck179 FIND v(dout0_10) AT=1800.05n

* CHECK dout0_11 Vdout0_11ck179 = 0 time = 1800
.meas tran vdout0_11ck179 FIND v(dout0_11) AT=1800.05n

* CHECK dout0_12 Vdout0_12ck179 = 1.8 time = 1800
.meas tran vdout0_12ck179 FIND v(dout0_12) AT=1800.05n

* CHECK dout0_13 Vdout0_13ck179 = 1.8 time = 1800
.meas tran vdout0_13ck179 FIND v(dout0_13) AT=1800.05n

* CHECK dout0_14 Vdout0_14ck179 = 1.8 time = 1800
.meas tran vdout0_14ck179 FIND v(dout0_14) AT=1800.05n

* CHECK dout0_15 Vdout0_15ck179 = 1.8 time = 1800
.meas tran vdout0_15ck179 FIND v(dout0_15) AT=1800.05n

* CHECK dout0_16 Vdout0_16ck179 = 1.8 time = 1800
.meas tran vdout0_16ck179 FIND v(dout0_16) AT=1800.05n

* CHECK dout0_17 Vdout0_17ck179 = 0 time = 1800
.meas tran vdout0_17ck179 FIND v(dout0_17) AT=1800.05n

* CHECK dout0_18 Vdout0_18ck179 = 1.8 time = 1800
.meas tran vdout0_18ck179 FIND v(dout0_18) AT=1800.05n

* CHECK dout0_19 Vdout0_19ck179 = 1.8 time = 1800
.meas tran vdout0_19ck179 FIND v(dout0_19) AT=1800.05n

* CHECK dout0_20 Vdout0_20ck179 = 1.8 time = 1800
.meas tran vdout0_20ck179 FIND v(dout0_20) AT=1800.05n

* CHECK dout0_21 Vdout0_21ck179 = 1.8 time = 1800
.meas tran vdout0_21ck179 FIND v(dout0_21) AT=1800.05n

* CHECK dout0_22 Vdout0_22ck179 = 1.8 time = 1800
.meas tran vdout0_22ck179 FIND v(dout0_22) AT=1800.05n

* CHECK dout0_23 Vdout0_23ck179 = 1.8 time = 1800
.meas tran vdout0_23ck179 FIND v(dout0_23) AT=1800.05n

* CHECK dout0_24 Vdout0_24ck179 = 0 time = 1800
.meas tran vdout0_24ck179 FIND v(dout0_24) AT=1800.05n

* CHECK dout0_25 Vdout0_25ck179 = 1.8 time = 1800
.meas tran vdout0_25ck179 FIND v(dout0_25) AT=1800.05n

* CHECK dout0_26 Vdout0_26ck179 = 0 time = 1800
.meas tran vdout0_26ck179 FIND v(dout0_26) AT=1800.05n

* CHECK dout0_27 Vdout0_27ck179 = 1.8 time = 1800
.meas tran vdout0_27ck179 FIND v(dout0_27) AT=1800.05n

* CHECK dout0_28 Vdout0_28ck179 = 1.8 time = 1800
.meas tran vdout0_28ck179 FIND v(dout0_28) AT=1800.05n

* CHECK dout0_29 Vdout0_29ck179 = 0 time = 1800
.meas tran vdout0_29ck179 FIND v(dout0_29) AT=1800.05n

* CHECK dout0_30 Vdout0_30ck179 = 1.8 time = 1800
.meas tran vdout0_30ck179 FIND v(dout0_30) AT=1800.05n

* CHECK dout0_31 Vdout0_31ck179 = 0 time = 1800
.meas tran vdout0_31ck179 FIND v(dout0_31) AT=1800.05n

* CHECK dout0_32 Vdout0_32ck179 = 0 time = 1800
.meas tran vdout0_32ck179 FIND v(dout0_32) AT=1800.05n

* CHECK dout0_0 Vdout0_0ck181 = 1.8 time = 1820
.meas tran vdout0_0ck181 FIND v(dout0_0) AT=1820.05n

* CHECK dout0_1 Vdout0_1ck181 = 0 time = 1820
.meas tran vdout0_1ck181 FIND v(dout0_1) AT=1820.05n

* CHECK dout0_2 Vdout0_2ck181 = 0 time = 1820
.meas tran vdout0_2ck181 FIND v(dout0_2) AT=1820.05n

* CHECK dout0_3 Vdout0_3ck181 = 1.8 time = 1820
.meas tran vdout0_3ck181 FIND v(dout0_3) AT=1820.05n

* CHECK dout0_4 Vdout0_4ck181 = 0 time = 1820
.meas tran vdout0_4ck181 FIND v(dout0_4) AT=1820.05n

* CHECK dout0_5 Vdout0_5ck181 = 1.8 time = 1820
.meas tran vdout0_5ck181 FIND v(dout0_5) AT=1820.05n

* CHECK dout0_6 Vdout0_6ck181 = 1.8 time = 1820
.meas tran vdout0_6ck181 FIND v(dout0_6) AT=1820.05n

* CHECK dout0_7 Vdout0_7ck181 = 0 time = 1820
.meas tran vdout0_7ck181 FIND v(dout0_7) AT=1820.05n

* CHECK dout0_8 Vdout0_8ck181 = 0 time = 1820
.meas tran vdout0_8ck181 FIND v(dout0_8) AT=1820.05n

* CHECK dout0_9 Vdout0_9ck181 = 0 time = 1820
.meas tran vdout0_9ck181 FIND v(dout0_9) AT=1820.05n

* CHECK dout0_10 Vdout0_10ck181 = 1.8 time = 1820
.meas tran vdout0_10ck181 FIND v(dout0_10) AT=1820.05n

* CHECK dout0_11 Vdout0_11ck181 = 0 time = 1820
.meas tran vdout0_11ck181 FIND v(dout0_11) AT=1820.05n

* CHECK dout0_12 Vdout0_12ck181 = 1.8 time = 1820
.meas tran vdout0_12ck181 FIND v(dout0_12) AT=1820.05n

* CHECK dout0_13 Vdout0_13ck181 = 1.8 time = 1820
.meas tran vdout0_13ck181 FIND v(dout0_13) AT=1820.05n

* CHECK dout0_14 Vdout0_14ck181 = 0 time = 1820
.meas tran vdout0_14ck181 FIND v(dout0_14) AT=1820.05n

* CHECK dout0_15 Vdout0_15ck181 = 1.8 time = 1820
.meas tran vdout0_15ck181 FIND v(dout0_15) AT=1820.05n

* CHECK dout0_16 Vdout0_16ck181 = 1.8 time = 1820
.meas tran vdout0_16ck181 FIND v(dout0_16) AT=1820.05n

* CHECK dout0_17 Vdout0_17ck181 = 1.8 time = 1820
.meas tran vdout0_17ck181 FIND v(dout0_17) AT=1820.05n

* CHECK dout0_18 Vdout0_18ck181 = 0 time = 1820
.meas tran vdout0_18ck181 FIND v(dout0_18) AT=1820.05n

* CHECK dout0_19 Vdout0_19ck181 = 1.8 time = 1820
.meas tran vdout0_19ck181 FIND v(dout0_19) AT=1820.05n

* CHECK dout0_20 Vdout0_20ck181 = 1.8 time = 1820
.meas tran vdout0_20ck181 FIND v(dout0_20) AT=1820.05n

* CHECK dout0_21 Vdout0_21ck181 = 1.8 time = 1820
.meas tran vdout0_21ck181 FIND v(dout0_21) AT=1820.05n

* CHECK dout0_22 Vdout0_22ck181 = 1.8 time = 1820
.meas tran vdout0_22ck181 FIND v(dout0_22) AT=1820.05n

* CHECK dout0_23 Vdout0_23ck181 = 1.8 time = 1820
.meas tran vdout0_23ck181 FIND v(dout0_23) AT=1820.05n

* CHECK dout0_24 Vdout0_24ck181 = 0 time = 1820
.meas tran vdout0_24ck181 FIND v(dout0_24) AT=1820.05n

* CHECK dout0_25 Vdout0_25ck181 = 1.8 time = 1820
.meas tran vdout0_25ck181 FIND v(dout0_25) AT=1820.05n

* CHECK dout0_26 Vdout0_26ck181 = 0 time = 1820
.meas tran vdout0_26ck181 FIND v(dout0_26) AT=1820.05n

* CHECK dout0_27 Vdout0_27ck181 = 1.8 time = 1820
.meas tran vdout0_27ck181 FIND v(dout0_27) AT=1820.05n

* CHECK dout0_28 Vdout0_28ck181 = 0 time = 1820
.meas tran vdout0_28ck181 FIND v(dout0_28) AT=1820.05n

* CHECK dout0_29 Vdout0_29ck181 = 0 time = 1820
.meas tran vdout0_29ck181 FIND v(dout0_29) AT=1820.05n

* CHECK dout0_30 Vdout0_30ck181 = 0 time = 1820
.meas tran vdout0_30ck181 FIND v(dout0_30) AT=1820.05n

* CHECK dout0_31 Vdout0_31ck181 = 1.8 time = 1820
.meas tran vdout0_31ck181 FIND v(dout0_31) AT=1820.05n

* CHECK dout0_32 Vdout0_32ck181 = 0 time = 1820
.meas tran vdout0_32ck181 FIND v(dout0_32) AT=1820.05n

* CHECK dout0_0 Vdout0_0ck182 = 1.8 time = 1830
.meas tran vdout0_0ck182 FIND v(dout0_0) AT=1830.05n

* CHECK dout0_1 Vdout0_1ck182 = 1.8 time = 1830
.meas tran vdout0_1ck182 FIND v(dout0_1) AT=1830.05n

* CHECK dout0_2 Vdout0_2ck182 = 0 time = 1830
.meas tran vdout0_2ck182 FIND v(dout0_2) AT=1830.05n

* CHECK dout0_3 Vdout0_3ck182 = 1.8 time = 1830
.meas tran vdout0_3ck182 FIND v(dout0_3) AT=1830.05n

* CHECK dout0_4 Vdout0_4ck182 = 1.8 time = 1830
.meas tran vdout0_4ck182 FIND v(dout0_4) AT=1830.05n

* CHECK dout0_5 Vdout0_5ck182 = 1.8 time = 1830
.meas tran vdout0_5ck182 FIND v(dout0_5) AT=1830.05n

* CHECK dout0_6 Vdout0_6ck182 = 1.8 time = 1830
.meas tran vdout0_6ck182 FIND v(dout0_6) AT=1830.05n

* CHECK dout0_7 Vdout0_7ck182 = 0 time = 1830
.meas tran vdout0_7ck182 FIND v(dout0_7) AT=1830.05n

* CHECK dout0_8 Vdout0_8ck182 = 1.8 time = 1830
.meas tran vdout0_8ck182 FIND v(dout0_8) AT=1830.05n

* CHECK dout0_9 Vdout0_9ck182 = 1.8 time = 1830
.meas tran vdout0_9ck182 FIND v(dout0_9) AT=1830.05n

* CHECK dout0_10 Vdout0_10ck182 = 1.8 time = 1830
.meas tran vdout0_10ck182 FIND v(dout0_10) AT=1830.05n

* CHECK dout0_11 Vdout0_11ck182 = 0 time = 1830
.meas tran vdout0_11ck182 FIND v(dout0_11) AT=1830.05n

* CHECK dout0_12 Vdout0_12ck182 = 1.8 time = 1830
.meas tran vdout0_12ck182 FIND v(dout0_12) AT=1830.05n

* CHECK dout0_13 Vdout0_13ck182 = 1.8 time = 1830
.meas tran vdout0_13ck182 FIND v(dout0_13) AT=1830.05n

* CHECK dout0_14 Vdout0_14ck182 = 1.8 time = 1830
.meas tran vdout0_14ck182 FIND v(dout0_14) AT=1830.05n

* CHECK dout0_15 Vdout0_15ck182 = 1.8 time = 1830
.meas tran vdout0_15ck182 FIND v(dout0_15) AT=1830.05n

* CHECK dout0_16 Vdout0_16ck182 = 1.8 time = 1830
.meas tran vdout0_16ck182 FIND v(dout0_16) AT=1830.05n

* CHECK dout0_17 Vdout0_17ck182 = 0 time = 1830
.meas tran vdout0_17ck182 FIND v(dout0_17) AT=1830.05n

* CHECK dout0_18 Vdout0_18ck182 = 1.8 time = 1830
.meas tran vdout0_18ck182 FIND v(dout0_18) AT=1830.05n

* CHECK dout0_19 Vdout0_19ck182 = 1.8 time = 1830
.meas tran vdout0_19ck182 FIND v(dout0_19) AT=1830.05n

* CHECK dout0_20 Vdout0_20ck182 = 1.8 time = 1830
.meas tran vdout0_20ck182 FIND v(dout0_20) AT=1830.05n

* CHECK dout0_21 Vdout0_21ck182 = 1.8 time = 1830
.meas tran vdout0_21ck182 FIND v(dout0_21) AT=1830.05n

* CHECK dout0_22 Vdout0_22ck182 = 1.8 time = 1830
.meas tran vdout0_22ck182 FIND v(dout0_22) AT=1830.05n

* CHECK dout0_23 Vdout0_23ck182 = 1.8 time = 1830
.meas tran vdout0_23ck182 FIND v(dout0_23) AT=1830.05n

* CHECK dout0_24 Vdout0_24ck182 = 0 time = 1830
.meas tran vdout0_24ck182 FIND v(dout0_24) AT=1830.05n

* CHECK dout0_25 Vdout0_25ck182 = 1.8 time = 1830
.meas tran vdout0_25ck182 FIND v(dout0_25) AT=1830.05n

* CHECK dout0_26 Vdout0_26ck182 = 0 time = 1830
.meas tran vdout0_26ck182 FIND v(dout0_26) AT=1830.05n

* CHECK dout0_27 Vdout0_27ck182 = 1.8 time = 1830
.meas tran vdout0_27ck182 FIND v(dout0_27) AT=1830.05n

* CHECK dout0_28 Vdout0_28ck182 = 1.8 time = 1830
.meas tran vdout0_28ck182 FIND v(dout0_28) AT=1830.05n

* CHECK dout0_29 Vdout0_29ck182 = 0 time = 1830
.meas tran vdout0_29ck182 FIND v(dout0_29) AT=1830.05n

* CHECK dout0_30 Vdout0_30ck182 = 1.8 time = 1830
.meas tran vdout0_30ck182 FIND v(dout0_30) AT=1830.05n

* CHECK dout0_31 Vdout0_31ck182 = 0 time = 1830
.meas tran vdout0_31ck182 FIND v(dout0_31) AT=1830.05n

* CHECK dout0_32 Vdout0_32ck182 = 0 time = 1830
.meas tran vdout0_32ck182 FIND v(dout0_32) AT=1830.05n

* CHECK dout0_0 Vdout0_0ck183 = 1.8 time = 1840
.meas tran vdout0_0ck183 FIND v(dout0_0) AT=1840.05n

* CHECK dout0_1 Vdout0_1ck183 = 0 time = 1840
.meas tran vdout0_1ck183 FIND v(dout0_1) AT=1840.05n

* CHECK dout0_2 Vdout0_2ck183 = 0 time = 1840
.meas tran vdout0_2ck183 FIND v(dout0_2) AT=1840.05n

* CHECK dout0_3 Vdout0_3ck183 = 1.8 time = 1840
.meas tran vdout0_3ck183 FIND v(dout0_3) AT=1840.05n

* CHECK dout0_4 Vdout0_4ck183 = 0 time = 1840
.meas tran vdout0_4ck183 FIND v(dout0_4) AT=1840.05n

* CHECK dout0_5 Vdout0_5ck183 = 1.8 time = 1840
.meas tran vdout0_5ck183 FIND v(dout0_5) AT=1840.05n

* CHECK dout0_6 Vdout0_6ck183 = 1.8 time = 1840
.meas tran vdout0_6ck183 FIND v(dout0_6) AT=1840.05n

* CHECK dout0_7 Vdout0_7ck183 = 0 time = 1840
.meas tran vdout0_7ck183 FIND v(dout0_7) AT=1840.05n

* CHECK dout0_8 Vdout0_8ck183 = 0 time = 1840
.meas tran vdout0_8ck183 FIND v(dout0_8) AT=1840.05n

* CHECK dout0_9 Vdout0_9ck183 = 0 time = 1840
.meas tran vdout0_9ck183 FIND v(dout0_9) AT=1840.05n

* CHECK dout0_10 Vdout0_10ck183 = 1.8 time = 1840
.meas tran vdout0_10ck183 FIND v(dout0_10) AT=1840.05n

* CHECK dout0_11 Vdout0_11ck183 = 0 time = 1840
.meas tran vdout0_11ck183 FIND v(dout0_11) AT=1840.05n

* CHECK dout0_12 Vdout0_12ck183 = 1.8 time = 1840
.meas tran vdout0_12ck183 FIND v(dout0_12) AT=1840.05n

* CHECK dout0_13 Vdout0_13ck183 = 1.8 time = 1840
.meas tran vdout0_13ck183 FIND v(dout0_13) AT=1840.05n

* CHECK dout0_14 Vdout0_14ck183 = 0 time = 1840
.meas tran vdout0_14ck183 FIND v(dout0_14) AT=1840.05n

* CHECK dout0_15 Vdout0_15ck183 = 1.8 time = 1840
.meas tran vdout0_15ck183 FIND v(dout0_15) AT=1840.05n

* CHECK dout0_16 Vdout0_16ck183 = 1.8 time = 1840
.meas tran vdout0_16ck183 FIND v(dout0_16) AT=1840.05n

* CHECK dout0_17 Vdout0_17ck183 = 1.8 time = 1840
.meas tran vdout0_17ck183 FIND v(dout0_17) AT=1840.05n

* CHECK dout0_18 Vdout0_18ck183 = 0 time = 1840
.meas tran vdout0_18ck183 FIND v(dout0_18) AT=1840.05n

* CHECK dout0_19 Vdout0_19ck183 = 1.8 time = 1840
.meas tran vdout0_19ck183 FIND v(dout0_19) AT=1840.05n

* CHECK dout0_20 Vdout0_20ck183 = 1.8 time = 1840
.meas tran vdout0_20ck183 FIND v(dout0_20) AT=1840.05n

* CHECK dout0_21 Vdout0_21ck183 = 1.8 time = 1840
.meas tran vdout0_21ck183 FIND v(dout0_21) AT=1840.05n

* CHECK dout0_22 Vdout0_22ck183 = 1.8 time = 1840
.meas tran vdout0_22ck183 FIND v(dout0_22) AT=1840.05n

* CHECK dout0_23 Vdout0_23ck183 = 1.8 time = 1840
.meas tran vdout0_23ck183 FIND v(dout0_23) AT=1840.05n

* CHECK dout0_24 Vdout0_24ck183 = 0 time = 1840
.meas tran vdout0_24ck183 FIND v(dout0_24) AT=1840.05n

* CHECK dout0_25 Vdout0_25ck183 = 1.8 time = 1840
.meas tran vdout0_25ck183 FIND v(dout0_25) AT=1840.05n

* CHECK dout0_26 Vdout0_26ck183 = 0 time = 1840
.meas tran vdout0_26ck183 FIND v(dout0_26) AT=1840.05n

* CHECK dout0_27 Vdout0_27ck183 = 1.8 time = 1840
.meas tran vdout0_27ck183 FIND v(dout0_27) AT=1840.05n

* CHECK dout0_28 Vdout0_28ck183 = 0 time = 1840
.meas tran vdout0_28ck183 FIND v(dout0_28) AT=1840.05n

* CHECK dout0_29 Vdout0_29ck183 = 0 time = 1840
.meas tran vdout0_29ck183 FIND v(dout0_29) AT=1840.05n

* CHECK dout0_30 Vdout0_30ck183 = 0 time = 1840
.meas tran vdout0_30ck183 FIND v(dout0_30) AT=1840.05n

* CHECK dout0_31 Vdout0_31ck183 = 1.8 time = 1840
.meas tran vdout0_31ck183 FIND v(dout0_31) AT=1840.05n

* CHECK dout0_32 Vdout0_32ck183 = 0 time = 1840
.meas tran vdout0_32ck183 FIND v(dout0_32) AT=1840.05n

* CHECK dout0_0 Vdout0_0ck184 = 1.8 time = 1850
.meas tran vdout0_0ck184 FIND v(dout0_0) AT=1850.05n

* CHECK dout0_1 Vdout0_1ck184 = 0 time = 1850
.meas tran vdout0_1ck184 FIND v(dout0_1) AT=1850.05n

* CHECK dout0_2 Vdout0_2ck184 = 0 time = 1850
.meas tran vdout0_2ck184 FIND v(dout0_2) AT=1850.05n

* CHECK dout0_3 Vdout0_3ck184 = 1.8 time = 1850
.meas tran vdout0_3ck184 FIND v(dout0_3) AT=1850.05n

* CHECK dout0_4 Vdout0_4ck184 = 0 time = 1850
.meas tran vdout0_4ck184 FIND v(dout0_4) AT=1850.05n

* CHECK dout0_5 Vdout0_5ck184 = 1.8 time = 1850
.meas tran vdout0_5ck184 FIND v(dout0_5) AT=1850.05n

* CHECK dout0_6 Vdout0_6ck184 = 1.8 time = 1850
.meas tran vdout0_6ck184 FIND v(dout0_6) AT=1850.05n

* CHECK dout0_7 Vdout0_7ck184 = 0 time = 1850
.meas tran vdout0_7ck184 FIND v(dout0_7) AT=1850.05n

* CHECK dout0_8 Vdout0_8ck184 = 0 time = 1850
.meas tran vdout0_8ck184 FIND v(dout0_8) AT=1850.05n

* CHECK dout0_9 Vdout0_9ck184 = 0 time = 1850
.meas tran vdout0_9ck184 FIND v(dout0_9) AT=1850.05n

* CHECK dout0_10 Vdout0_10ck184 = 1.8 time = 1850
.meas tran vdout0_10ck184 FIND v(dout0_10) AT=1850.05n

* CHECK dout0_11 Vdout0_11ck184 = 0 time = 1850
.meas tran vdout0_11ck184 FIND v(dout0_11) AT=1850.05n

* CHECK dout0_12 Vdout0_12ck184 = 1.8 time = 1850
.meas tran vdout0_12ck184 FIND v(dout0_12) AT=1850.05n

* CHECK dout0_13 Vdout0_13ck184 = 1.8 time = 1850
.meas tran vdout0_13ck184 FIND v(dout0_13) AT=1850.05n

* CHECK dout0_14 Vdout0_14ck184 = 0 time = 1850
.meas tran vdout0_14ck184 FIND v(dout0_14) AT=1850.05n

* CHECK dout0_15 Vdout0_15ck184 = 1.8 time = 1850
.meas tran vdout0_15ck184 FIND v(dout0_15) AT=1850.05n

* CHECK dout0_16 Vdout0_16ck184 = 1.8 time = 1850
.meas tran vdout0_16ck184 FIND v(dout0_16) AT=1850.05n

* CHECK dout0_17 Vdout0_17ck184 = 1.8 time = 1850
.meas tran vdout0_17ck184 FIND v(dout0_17) AT=1850.05n

* CHECK dout0_18 Vdout0_18ck184 = 0 time = 1850
.meas tran vdout0_18ck184 FIND v(dout0_18) AT=1850.05n

* CHECK dout0_19 Vdout0_19ck184 = 1.8 time = 1850
.meas tran vdout0_19ck184 FIND v(dout0_19) AT=1850.05n

* CHECK dout0_20 Vdout0_20ck184 = 1.8 time = 1850
.meas tran vdout0_20ck184 FIND v(dout0_20) AT=1850.05n

* CHECK dout0_21 Vdout0_21ck184 = 1.8 time = 1850
.meas tran vdout0_21ck184 FIND v(dout0_21) AT=1850.05n

* CHECK dout0_22 Vdout0_22ck184 = 1.8 time = 1850
.meas tran vdout0_22ck184 FIND v(dout0_22) AT=1850.05n

* CHECK dout0_23 Vdout0_23ck184 = 1.8 time = 1850
.meas tran vdout0_23ck184 FIND v(dout0_23) AT=1850.05n

* CHECK dout0_24 Vdout0_24ck184 = 0 time = 1850
.meas tran vdout0_24ck184 FIND v(dout0_24) AT=1850.05n

* CHECK dout0_25 Vdout0_25ck184 = 1.8 time = 1850
.meas tran vdout0_25ck184 FIND v(dout0_25) AT=1850.05n

* CHECK dout0_26 Vdout0_26ck184 = 0 time = 1850
.meas tran vdout0_26ck184 FIND v(dout0_26) AT=1850.05n

* CHECK dout0_27 Vdout0_27ck184 = 1.8 time = 1850
.meas tran vdout0_27ck184 FIND v(dout0_27) AT=1850.05n

* CHECK dout0_28 Vdout0_28ck184 = 0 time = 1850
.meas tran vdout0_28ck184 FIND v(dout0_28) AT=1850.05n

* CHECK dout0_29 Vdout0_29ck184 = 0 time = 1850
.meas tran vdout0_29ck184 FIND v(dout0_29) AT=1850.05n

* CHECK dout0_30 Vdout0_30ck184 = 0 time = 1850
.meas tran vdout0_30ck184 FIND v(dout0_30) AT=1850.05n

* CHECK dout0_31 Vdout0_31ck184 = 1.8 time = 1850
.meas tran vdout0_31ck184 FIND v(dout0_31) AT=1850.05n

* CHECK dout0_32 Vdout0_32ck184 = 0 time = 1850
.meas tran vdout0_32ck184 FIND v(dout0_32) AT=1850.05n

* CHECK dout0_0 Vdout0_0ck185 = 1.8 time = 1860
.meas tran vdout0_0ck185 FIND v(dout0_0) AT=1860.05n

* CHECK dout0_1 Vdout0_1ck185 = 0 time = 1860
.meas tran vdout0_1ck185 FIND v(dout0_1) AT=1860.05n

* CHECK dout0_2 Vdout0_2ck185 = 0 time = 1860
.meas tran vdout0_2ck185 FIND v(dout0_2) AT=1860.05n

* CHECK dout0_3 Vdout0_3ck185 = 1.8 time = 1860
.meas tran vdout0_3ck185 FIND v(dout0_3) AT=1860.05n

* CHECK dout0_4 Vdout0_4ck185 = 0 time = 1860
.meas tran vdout0_4ck185 FIND v(dout0_4) AT=1860.05n

* CHECK dout0_5 Vdout0_5ck185 = 1.8 time = 1860
.meas tran vdout0_5ck185 FIND v(dout0_5) AT=1860.05n

* CHECK dout0_6 Vdout0_6ck185 = 1.8 time = 1860
.meas tran vdout0_6ck185 FIND v(dout0_6) AT=1860.05n

* CHECK dout0_7 Vdout0_7ck185 = 0 time = 1860
.meas tran vdout0_7ck185 FIND v(dout0_7) AT=1860.05n

* CHECK dout0_8 Vdout0_8ck185 = 0 time = 1860
.meas tran vdout0_8ck185 FIND v(dout0_8) AT=1860.05n

* CHECK dout0_9 Vdout0_9ck185 = 0 time = 1860
.meas tran vdout0_9ck185 FIND v(dout0_9) AT=1860.05n

* CHECK dout0_10 Vdout0_10ck185 = 1.8 time = 1860
.meas tran vdout0_10ck185 FIND v(dout0_10) AT=1860.05n

* CHECK dout0_11 Vdout0_11ck185 = 0 time = 1860
.meas tran vdout0_11ck185 FIND v(dout0_11) AT=1860.05n

* CHECK dout0_12 Vdout0_12ck185 = 1.8 time = 1860
.meas tran vdout0_12ck185 FIND v(dout0_12) AT=1860.05n

* CHECK dout0_13 Vdout0_13ck185 = 1.8 time = 1860
.meas tran vdout0_13ck185 FIND v(dout0_13) AT=1860.05n

* CHECK dout0_14 Vdout0_14ck185 = 0 time = 1860
.meas tran vdout0_14ck185 FIND v(dout0_14) AT=1860.05n

* CHECK dout0_15 Vdout0_15ck185 = 1.8 time = 1860
.meas tran vdout0_15ck185 FIND v(dout0_15) AT=1860.05n

* CHECK dout0_16 Vdout0_16ck185 = 1.8 time = 1860
.meas tran vdout0_16ck185 FIND v(dout0_16) AT=1860.05n

* CHECK dout0_17 Vdout0_17ck185 = 1.8 time = 1860
.meas tran vdout0_17ck185 FIND v(dout0_17) AT=1860.05n

* CHECK dout0_18 Vdout0_18ck185 = 0 time = 1860
.meas tran vdout0_18ck185 FIND v(dout0_18) AT=1860.05n

* CHECK dout0_19 Vdout0_19ck185 = 1.8 time = 1860
.meas tran vdout0_19ck185 FIND v(dout0_19) AT=1860.05n

* CHECK dout0_20 Vdout0_20ck185 = 1.8 time = 1860
.meas tran vdout0_20ck185 FIND v(dout0_20) AT=1860.05n

* CHECK dout0_21 Vdout0_21ck185 = 1.8 time = 1860
.meas tran vdout0_21ck185 FIND v(dout0_21) AT=1860.05n

* CHECK dout0_22 Vdout0_22ck185 = 1.8 time = 1860
.meas tran vdout0_22ck185 FIND v(dout0_22) AT=1860.05n

* CHECK dout0_23 Vdout0_23ck185 = 1.8 time = 1860
.meas tran vdout0_23ck185 FIND v(dout0_23) AT=1860.05n

* CHECK dout0_24 Vdout0_24ck185 = 0 time = 1860
.meas tran vdout0_24ck185 FIND v(dout0_24) AT=1860.05n

* CHECK dout0_25 Vdout0_25ck185 = 1.8 time = 1860
.meas tran vdout0_25ck185 FIND v(dout0_25) AT=1860.05n

* CHECK dout0_26 Vdout0_26ck185 = 0 time = 1860
.meas tran vdout0_26ck185 FIND v(dout0_26) AT=1860.05n

* CHECK dout0_27 Vdout0_27ck185 = 1.8 time = 1860
.meas tran vdout0_27ck185 FIND v(dout0_27) AT=1860.05n

* CHECK dout0_28 Vdout0_28ck185 = 0 time = 1860
.meas tran vdout0_28ck185 FIND v(dout0_28) AT=1860.05n

* CHECK dout0_29 Vdout0_29ck185 = 0 time = 1860
.meas tran vdout0_29ck185 FIND v(dout0_29) AT=1860.05n

* CHECK dout0_30 Vdout0_30ck185 = 0 time = 1860
.meas tran vdout0_30ck185 FIND v(dout0_30) AT=1860.05n

* CHECK dout0_31 Vdout0_31ck185 = 1.8 time = 1860
.meas tran vdout0_31ck185 FIND v(dout0_31) AT=1860.05n

* CHECK dout0_32 Vdout0_32ck185 = 0 time = 1860
.meas tran vdout0_32ck185 FIND v(dout0_32) AT=1860.05n

* CHECK dout0_0 Vdout0_0ck186 = 1.8 time = 1870
.meas tran vdout0_0ck186 FIND v(dout0_0) AT=1870.05n

* CHECK dout0_1 Vdout0_1ck186 = 1.8 time = 1870
.meas tran vdout0_1ck186 FIND v(dout0_1) AT=1870.05n

* CHECK dout0_2 Vdout0_2ck186 = 0 time = 1870
.meas tran vdout0_2ck186 FIND v(dout0_2) AT=1870.05n

* CHECK dout0_3 Vdout0_3ck186 = 1.8 time = 1870
.meas tran vdout0_3ck186 FIND v(dout0_3) AT=1870.05n

* CHECK dout0_4 Vdout0_4ck186 = 1.8 time = 1870
.meas tran vdout0_4ck186 FIND v(dout0_4) AT=1870.05n

* CHECK dout0_5 Vdout0_5ck186 = 1.8 time = 1870
.meas tran vdout0_5ck186 FIND v(dout0_5) AT=1870.05n

* CHECK dout0_6 Vdout0_6ck186 = 1.8 time = 1870
.meas tran vdout0_6ck186 FIND v(dout0_6) AT=1870.05n

* CHECK dout0_7 Vdout0_7ck186 = 0 time = 1870
.meas tran vdout0_7ck186 FIND v(dout0_7) AT=1870.05n

* CHECK dout0_8 Vdout0_8ck186 = 1.8 time = 1870
.meas tran vdout0_8ck186 FIND v(dout0_8) AT=1870.05n

* CHECK dout0_9 Vdout0_9ck186 = 1.8 time = 1870
.meas tran vdout0_9ck186 FIND v(dout0_9) AT=1870.05n

* CHECK dout0_10 Vdout0_10ck186 = 1.8 time = 1870
.meas tran vdout0_10ck186 FIND v(dout0_10) AT=1870.05n

* CHECK dout0_11 Vdout0_11ck186 = 0 time = 1870
.meas tran vdout0_11ck186 FIND v(dout0_11) AT=1870.05n

* CHECK dout0_12 Vdout0_12ck186 = 1.8 time = 1870
.meas tran vdout0_12ck186 FIND v(dout0_12) AT=1870.05n

* CHECK dout0_13 Vdout0_13ck186 = 1.8 time = 1870
.meas tran vdout0_13ck186 FIND v(dout0_13) AT=1870.05n

* CHECK dout0_14 Vdout0_14ck186 = 1.8 time = 1870
.meas tran vdout0_14ck186 FIND v(dout0_14) AT=1870.05n

* CHECK dout0_15 Vdout0_15ck186 = 1.8 time = 1870
.meas tran vdout0_15ck186 FIND v(dout0_15) AT=1870.05n

* CHECK dout0_16 Vdout0_16ck186 = 1.8 time = 1870
.meas tran vdout0_16ck186 FIND v(dout0_16) AT=1870.05n

* CHECK dout0_17 Vdout0_17ck186 = 0 time = 1870
.meas tran vdout0_17ck186 FIND v(dout0_17) AT=1870.05n

* CHECK dout0_18 Vdout0_18ck186 = 1.8 time = 1870
.meas tran vdout0_18ck186 FIND v(dout0_18) AT=1870.05n

* CHECK dout0_19 Vdout0_19ck186 = 1.8 time = 1870
.meas tran vdout0_19ck186 FIND v(dout0_19) AT=1870.05n

* CHECK dout0_20 Vdout0_20ck186 = 1.8 time = 1870
.meas tran vdout0_20ck186 FIND v(dout0_20) AT=1870.05n

* CHECK dout0_21 Vdout0_21ck186 = 1.8 time = 1870
.meas tran vdout0_21ck186 FIND v(dout0_21) AT=1870.05n

* CHECK dout0_22 Vdout0_22ck186 = 1.8 time = 1870
.meas tran vdout0_22ck186 FIND v(dout0_22) AT=1870.05n

* CHECK dout0_23 Vdout0_23ck186 = 1.8 time = 1870
.meas tran vdout0_23ck186 FIND v(dout0_23) AT=1870.05n

* CHECK dout0_24 Vdout0_24ck186 = 0 time = 1870
.meas tran vdout0_24ck186 FIND v(dout0_24) AT=1870.05n

* CHECK dout0_25 Vdout0_25ck186 = 1.8 time = 1870
.meas tran vdout0_25ck186 FIND v(dout0_25) AT=1870.05n

* CHECK dout0_26 Vdout0_26ck186 = 0 time = 1870
.meas tran vdout0_26ck186 FIND v(dout0_26) AT=1870.05n

* CHECK dout0_27 Vdout0_27ck186 = 1.8 time = 1870
.meas tran vdout0_27ck186 FIND v(dout0_27) AT=1870.05n

* CHECK dout0_28 Vdout0_28ck186 = 1.8 time = 1870
.meas tran vdout0_28ck186 FIND v(dout0_28) AT=1870.05n

* CHECK dout0_29 Vdout0_29ck186 = 0 time = 1870
.meas tran vdout0_29ck186 FIND v(dout0_29) AT=1870.05n

* CHECK dout0_30 Vdout0_30ck186 = 1.8 time = 1870
.meas tran vdout0_30ck186 FIND v(dout0_30) AT=1870.05n

* CHECK dout0_31 Vdout0_31ck186 = 0 time = 1870
.meas tran vdout0_31ck186 FIND v(dout0_31) AT=1870.05n

* CHECK dout0_32 Vdout0_32ck186 = 0 time = 1870
.meas tran vdout0_32ck186 FIND v(dout0_32) AT=1870.05n

* CHECK dout0_0 Vdout0_0ck191 = 0 time = 1920
.meas tran vdout0_0ck191 FIND v(dout0_0) AT=1920.05n

* CHECK dout0_1 Vdout0_1ck191 = 0 time = 1920
.meas tran vdout0_1ck191 FIND v(dout0_1) AT=1920.05n

* CHECK dout0_2 Vdout0_2ck191 = 0 time = 1920
.meas tran vdout0_2ck191 FIND v(dout0_2) AT=1920.05n

* CHECK dout0_3 Vdout0_3ck191 = 1.8 time = 1920
.meas tran vdout0_3ck191 FIND v(dout0_3) AT=1920.05n

* CHECK dout0_4 Vdout0_4ck191 = 0 time = 1920
.meas tran vdout0_4ck191 FIND v(dout0_4) AT=1920.05n

* CHECK dout0_5 Vdout0_5ck191 = 0 time = 1920
.meas tran vdout0_5ck191 FIND v(dout0_5) AT=1920.05n

* CHECK dout0_6 Vdout0_6ck191 = 0 time = 1920
.meas tran vdout0_6ck191 FIND v(dout0_6) AT=1920.05n

* CHECK dout0_7 Vdout0_7ck191 = 1.8 time = 1920
.meas tran vdout0_7ck191 FIND v(dout0_7) AT=1920.05n

* CHECK dout0_8 Vdout0_8ck191 = 1.8 time = 1920
.meas tran vdout0_8ck191 FIND v(dout0_8) AT=1920.05n

* CHECK dout0_9 Vdout0_9ck191 = 0 time = 1920
.meas tran vdout0_9ck191 FIND v(dout0_9) AT=1920.05n

* CHECK dout0_10 Vdout0_10ck191 = 1.8 time = 1920
.meas tran vdout0_10ck191 FIND v(dout0_10) AT=1920.05n

* CHECK dout0_11 Vdout0_11ck191 = 1.8 time = 1920
.meas tran vdout0_11ck191 FIND v(dout0_11) AT=1920.05n

* CHECK dout0_12 Vdout0_12ck191 = 0 time = 1920
.meas tran vdout0_12ck191 FIND v(dout0_12) AT=1920.05n

* CHECK dout0_13 Vdout0_13ck191 = 0 time = 1920
.meas tran vdout0_13ck191 FIND v(dout0_13) AT=1920.05n

* CHECK dout0_14 Vdout0_14ck191 = 0 time = 1920
.meas tran vdout0_14ck191 FIND v(dout0_14) AT=1920.05n

* CHECK dout0_15 Vdout0_15ck191 = 0 time = 1920
.meas tran vdout0_15ck191 FIND v(dout0_15) AT=1920.05n

* CHECK dout0_16 Vdout0_16ck191 = 0 time = 1920
.meas tran vdout0_16ck191 FIND v(dout0_16) AT=1920.05n

* CHECK dout0_17 Vdout0_17ck191 = 0 time = 1920
.meas tran vdout0_17ck191 FIND v(dout0_17) AT=1920.05n

* CHECK dout0_18 Vdout0_18ck191 = 0 time = 1920
.meas tran vdout0_18ck191 FIND v(dout0_18) AT=1920.05n

* CHECK dout0_19 Vdout0_19ck191 = 1.8 time = 1920
.meas tran vdout0_19ck191 FIND v(dout0_19) AT=1920.05n

* CHECK dout0_20 Vdout0_20ck191 = 0 time = 1920
.meas tran vdout0_20ck191 FIND v(dout0_20) AT=1920.05n

* CHECK dout0_21 Vdout0_21ck191 = 1.8 time = 1920
.meas tran vdout0_21ck191 FIND v(dout0_21) AT=1920.05n

* CHECK dout0_22 Vdout0_22ck191 = 1.8 time = 1920
.meas tran vdout0_22ck191 FIND v(dout0_22) AT=1920.05n

* CHECK dout0_23 Vdout0_23ck191 = 0 time = 1920
.meas tran vdout0_23ck191 FIND v(dout0_23) AT=1920.05n

* CHECK dout0_24 Vdout0_24ck191 = 0 time = 1920
.meas tran vdout0_24ck191 FIND v(dout0_24) AT=1920.05n

* CHECK dout0_25 Vdout0_25ck191 = 1.8 time = 1920
.meas tran vdout0_25ck191 FIND v(dout0_25) AT=1920.05n

* CHECK dout0_26 Vdout0_26ck191 = 0 time = 1920
.meas tran vdout0_26ck191 FIND v(dout0_26) AT=1920.05n

* CHECK dout0_27 Vdout0_27ck191 = 1.8 time = 1920
.meas tran vdout0_27ck191 FIND v(dout0_27) AT=1920.05n

* CHECK dout0_28 Vdout0_28ck191 = 1.8 time = 1920
.meas tran vdout0_28ck191 FIND v(dout0_28) AT=1920.05n

* CHECK dout0_29 Vdout0_29ck191 = 0 time = 1920
.meas tran vdout0_29ck191 FIND v(dout0_29) AT=1920.05n

* CHECK dout0_30 Vdout0_30ck191 = 1.8 time = 1920
.meas tran vdout0_30ck191 FIND v(dout0_30) AT=1920.05n

* CHECK dout0_31 Vdout0_31ck191 = 1.8 time = 1920
.meas tran vdout0_31ck191 FIND v(dout0_31) AT=1920.05n

* CHECK dout0_32 Vdout0_32ck191 = 0 time = 1920
.meas tran vdout0_32ck191 FIND v(dout0_32) AT=1920.05n

* CHECK dout0_0 Vdout0_0ck192 = 0 time = 1930
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=1930.05n

* CHECK dout0_1 Vdout0_1ck192 = 0 time = 1930
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=1930.05n

* CHECK dout0_2 Vdout0_2ck192 = 0 time = 1930
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=1930.05n

* CHECK dout0_3 Vdout0_3ck192 = 1.8 time = 1930
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=1930.05n

* CHECK dout0_4 Vdout0_4ck192 = 0 time = 1930
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=1930.05n

* CHECK dout0_5 Vdout0_5ck192 = 0 time = 1930
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=1930.05n

* CHECK dout0_6 Vdout0_6ck192 = 0 time = 1930
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=1930.05n

* CHECK dout0_7 Vdout0_7ck192 = 1.8 time = 1930
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=1930.05n

* CHECK dout0_8 Vdout0_8ck192 = 1.8 time = 1930
.meas tran vdout0_8ck192 FIND v(dout0_8) AT=1930.05n

* CHECK dout0_9 Vdout0_9ck192 = 0 time = 1930
.meas tran vdout0_9ck192 FIND v(dout0_9) AT=1930.05n

* CHECK dout0_10 Vdout0_10ck192 = 1.8 time = 1930
.meas tran vdout0_10ck192 FIND v(dout0_10) AT=1930.05n

* CHECK dout0_11 Vdout0_11ck192 = 1.8 time = 1930
.meas tran vdout0_11ck192 FIND v(dout0_11) AT=1930.05n

* CHECK dout0_12 Vdout0_12ck192 = 0 time = 1930
.meas tran vdout0_12ck192 FIND v(dout0_12) AT=1930.05n

* CHECK dout0_13 Vdout0_13ck192 = 0 time = 1930
.meas tran vdout0_13ck192 FIND v(dout0_13) AT=1930.05n

* CHECK dout0_14 Vdout0_14ck192 = 0 time = 1930
.meas tran vdout0_14ck192 FIND v(dout0_14) AT=1930.05n

* CHECK dout0_15 Vdout0_15ck192 = 0 time = 1930
.meas tran vdout0_15ck192 FIND v(dout0_15) AT=1930.05n

* CHECK dout0_16 Vdout0_16ck192 = 0 time = 1930
.meas tran vdout0_16ck192 FIND v(dout0_16) AT=1930.05n

* CHECK dout0_17 Vdout0_17ck192 = 0 time = 1930
.meas tran vdout0_17ck192 FIND v(dout0_17) AT=1930.05n

* CHECK dout0_18 Vdout0_18ck192 = 0 time = 1930
.meas tran vdout0_18ck192 FIND v(dout0_18) AT=1930.05n

* CHECK dout0_19 Vdout0_19ck192 = 1.8 time = 1930
.meas tran vdout0_19ck192 FIND v(dout0_19) AT=1930.05n

* CHECK dout0_20 Vdout0_20ck192 = 0 time = 1930
.meas tran vdout0_20ck192 FIND v(dout0_20) AT=1930.05n

* CHECK dout0_21 Vdout0_21ck192 = 1.8 time = 1930
.meas tran vdout0_21ck192 FIND v(dout0_21) AT=1930.05n

* CHECK dout0_22 Vdout0_22ck192 = 1.8 time = 1930
.meas tran vdout0_22ck192 FIND v(dout0_22) AT=1930.05n

* CHECK dout0_23 Vdout0_23ck192 = 0 time = 1930
.meas tran vdout0_23ck192 FIND v(dout0_23) AT=1930.05n

* CHECK dout0_24 Vdout0_24ck192 = 0 time = 1930
.meas tran vdout0_24ck192 FIND v(dout0_24) AT=1930.05n

* CHECK dout0_25 Vdout0_25ck192 = 1.8 time = 1930
.meas tran vdout0_25ck192 FIND v(dout0_25) AT=1930.05n

* CHECK dout0_26 Vdout0_26ck192 = 0 time = 1930
.meas tran vdout0_26ck192 FIND v(dout0_26) AT=1930.05n

* CHECK dout0_27 Vdout0_27ck192 = 1.8 time = 1930
.meas tran vdout0_27ck192 FIND v(dout0_27) AT=1930.05n

* CHECK dout0_28 Vdout0_28ck192 = 1.8 time = 1930
.meas tran vdout0_28ck192 FIND v(dout0_28) AT=1930.05n

* CHECK dout0_29 Vdout0_29ck192 = 0 time = 1930
.meas tran vdout0_29ck192 FIND v(dout0_29) AT=1930.05n

* CHECK dout0_30 Vdout0_30ck192 = 1.8 time = 1930
.meas tran vdout0_30ck192 FIND v(dout0_30) AT=1930.05n

* CHECK dout0_31 Vdout0_31ck192 = 1.8 time = 1930
.meas tran vdout0_31ck192 FIND v(dout0_31) AT=1930.05n

* CHECK dout0_32 Vdout0_32ck192 = 0 time = 1930
.meas tran vdout0_32ck192 FIND v(dout0_32) AT=1930.05n

* CHECK dout0_0 Vdout0_0ck194 = 1.8 time = 1950
.meas tran vdout0_0ck194 FIND v(dout0_0) AT=1950.05n

* CHECK dout0_1 Vdout0_1ck194 = 1.8 time = 1950
.meas tran vdout0_1ck194 FIND v(dout0_1) AT=1950.05n

* CHECK dout0_2 Vdout0_2ck194 = 0 time = 1950
.meas tran vdout0_2ck194 FIND v(dout0_2) AT=1950.05n

* CHECK dout0_3 Vdout0_3ck194 = 0 time = 1950
.meas tran vdout0_3ck194 FIND v(dout0_3) AT=1950.05n

* CHECK dout0_4 Vdout0_4ck194 = 0 time = 1950
.meas tran vdout0_4ck194 FIND v(dout0_4) AT=1950.05n

* CHECK dout0_5 Vdout0_5ck194 = 1.8 time = 1950
.meas tran vdout0_5ck194 FIND v(dout0_5) AT=1950.05n

* CHECK dout0_6 Vdout0_6ck194 = 0 time = 1950
.meas tran vdout0_6ck194 FIND v(dout0_6) AT=1950.05n

* CHECK dout0_7 Vdout0_7ck194 = 1.8 time = 1950
.meas tran vdout0_7ck194 FIND v(dout0_7) AT=1950.05n

* CHECK dout0_8 Vdout0_8ck194 = 1.8 time = 1950
.meas tran vdout0_8ck194 FIND v(dout0_8) AT=1950.05n

* CHECK dout0_9 Vdout0_9ck194 = 0 time = 1950
.meas tran vdout0_9ck194 FIND v(dout0_9) AT=1950.05n

* CHECK dout0_10 Vdout0_10ck194 = 1.8 time = 1950
.meas tran vdout0_10ck194 FIND v(dout0_10) AT=1950.05n

* CHECK dout0_11 Vdout0_11ck194 = 0 time = 1950
.meas tran vdout0_11ck194 FIND v(dout0_11) AT=1950.05n

* CHECK dout0_12 Vdout0_12ck194 = 1.8 time = 1950
.meas tran vdout0_12ck194 FIND v(dout0_12) AT=1950.05n

* CHECK dout0_13 Vdout0_13ck194 = 0 time = 1950
.meas tran vdout0_13ck194 FIND v(dout0_13) AT=1950.05n

* CHECK dout0_14 Vdout0_14ck194 = 0 time = 1950
.meas tran vdout0_14ck194 FIND v(dout0_14) AT=1950.05n

* CHECK dout0_15 Vdout0_15ck194 = 1.8 time = 1950
.meas tran vdout0_15ck194 FIND v(dout0_15) AT=1950.05n

* CHECK dout0_16 Vdout0_16ck194 = 0 time = 1950
.meas tran vdout0_16ck194 FIND v(dout0_16) AT=1950.05n

* CHECK dout0_17 Vdout0_17ck194 = 1.8 time = 1950
.meas tran vdout0_17ck194 FIND v(dout0_17) AT=1950.05n

* CHECK dout0_18 Vdout0_18ck194 = 1.8 time = 1950
.meas tran vdout0_18ck194 FIND v(dout0_18) AT=1950.05n

* CHECK dout0_19 Vdout0_19ck194 = 1.8 time = 1950
.meas tran vdout0_19ck194 FIND v(dout0_19) AT=1950.05n

* CHECK dout0_20 Vdout0_20ck194 = 1.8 time = 1950
.meas tran vdout0_20ck194 FIND v(dout0_20) AT=1950.05n

* CHECK dout0_21 Vdout0_21ck194 = 0 time = 1950
.meas tran vdout0_21ck194 FIND v(dout0_21) AT=1950.05n

* CHECK dout0_22 Vdout0_22ck194 = 0 time = 1950
.meas tran vdout0_22ck194 FIND v(dout0_22) AT=1950.05n

* CHECK dout0_23 Vdout0_23ck194 = 1.8 time = 1950
.meas tran vdout0_23ck194 FIND v(dout0_23) AT=1950.05n

* CHECK dout0_24 Vdout0_24ck194 = 1.8 time = 1950
.meas tran vdout0_24ck194 FIND v(dout0_24) AT=1950.05n

* CHECK dout0_25 Vdout0_25ck194 = 0 time = 1950
.meas tran vdout0_25ck194 FIND v(dout0_25) AT=1950.05n

* CHECK dout0_26 Vdout0_26ck194 = 0 time = 1950
.meas tran vdout0_26ck194 FIND v(dout0_26) AT=1950.05n

* CHECK dout0_27 Vdout0_27ck194 = 1.8 time = 1950
.meas tran vdout0_27ck194 FIND v(dout0_27) AT=1950.05n

* CHECK dout0_28 Vdout0_28ck194 = 0 time = 1950
.meas tran vdout0_28ck194 FIND v(dout0_28) AT=1950.05n

* CHECK dout0_29 Vdout0_29ck194 = 1.8 time = 1950
.meas tran vdout0_29ck194 FIND v(dout0_29) AT=1950.05n

* CHECK dout0_30 Vdout0_30ck194 = 1.8 time = 1950
.meas tran vdout0_30ck194 FIND v(dout0_30) AT=1950.05n

* CHECK dout0_31 Vdout0_31ck194 = 0 time = 1950
.meas tran vdout0_31ck194 FIND v(dout0_31) AT=1950.05n

* CHECK dout0_32 Vdout0_32ck194 = 0 time = 1950
.meas tran vdout0_32ck194 FIND v(dout0_32) AT=1950.05n

* CHECK dout0_0 Vdout0_0ck197 = 0 time = 1980
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=1980.05n

* CHECK dout0_1 Vdout0_1ck197 = 0 time = 1980
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=1980.05n

* CHECK dout0_2 Vdout0_2ck197 = 0 time = 1980
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=1980.05n

* CHECK dout0_3 Vdout0_3ck197 = 1.8 time = 1980
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=1980.05n

* CHECK dout0_4 Vdout0_4ck197 = 0 time = 1980
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=1980.05n

* CHECK dout0_5 Vdout0_5ck197 = 0 time = 1980
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=1980.05n

* CHECK dout0_6 Vdout0_6ck197 = 0 time = 1980
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=1980.05n

* CHECK dout0_7 Vdout0_7ck197 = 1.8 time = 1980
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=1980.05n

* CHECK dout0_8 Vdout0_8ck197 = 1.8 time = 1980
.meas tran vdout0_8ck197 FIND v(dout0_8) AT=1980.05n

* CHECK dout0_9 Vdout0_9ck197 = 0 time = 1980
.meas tran vdout0_9ck197 FIND v(dout0_9) AT=1980.05n

* CHECK dout0_10 Vdout0_10ck197 = 1.8 time = 1980
.meas tran vdout0_10ck197 FIND v(dout0_10) AT=1980.05n

* CHECK dout0_11 Vdout0_11ck197 = 1.8 time = 1980
.meas tran vdout0_11ck197 FIND v(dout0_11) AT=1980.05n

* CHECK dout0_12 Vdout0_12ck197 = 0 time = 1980
.meas tran vdout0_12ck197 FIND v(dout0_12) AT=1980.05n

* CHECK dout0_13 Vdout0_13ck197 = 0 time = 1980
.meas tran vdout0_13ck197 FIND v(dout0_13) AT=1980.05n

* CHECK dout0_14 Vdout0_14ck197 = 0 time = 1980
.meas tran vdout0_14ck197 FIND v(dout0_14) AT=1980.05n

* CHECK dout0_15 Vdout0_15ck197 = 0 time = 1980
.meas tran vdout0_15ck197 FIND v(dout0_15) AT=1980.05n

* CHECK dout0_16 Vdout0_16ck197 = 0 time = 1980
.meas tran vdout0_16ck197 FIND v(dout0_16) AT=1980.05n

* CHECK dout0_17 Vdout0_17ck197 = 0 time = 1980
.meas tran vdout0_17ck197 FIND v(dout0_17) AT=1980.05n

* CHECK dout0_18 Vdout0_18ck197 = 0 time = 1980
.meas tran vdout0_18ck197 FIND v(dout0_18) AT=1980.05n

* CHECK dout0_19 Vdout0_19ck197 = 1.8 time = 1980
.meas tran vdout0_19ck197 FIND v(dout0_19) AT=1980.05n

* CHECK dout0_20 Vdout0_20ck197 = 0 time = 1980
.meas tran vdout0_20ck197 FIND v(dout0_20) AT=1980.05n

* CHECK dout0_21 Vdout0_21ck197 = 1.8 time = 1980
.meas tran vdout0_21ck197 FIND v(dout0_21) AT=1980.05n

* CHECK dout0_22 Vdout0_22ck197 = 1.8 time = 1980
.meas tran vdout0_22ck197 FIND v(dout0_22) AT=1980.05n

* CHECK dout0_23 Vdout0_23ck197 = 0 time = 1980
.meas tran vdout0_23ck197 FIND v(dout0_23) AT=1980.05n

* CHECK dout0_24 Vdout0_24ck197 = 0 time = 1980
.meas tran vdout0_24ck197 FIND v(dout0_24) AT=1980.05n

* CHECK dout0_25 Vdout0_25ck197 = 1.8 time = 1980
.meas tran vdout0_25ck197 FIND v(dout0_25) AT=1980.05n

* CHECK dout0_26 Vdout0_26ck197 = 0 time = 1980
.meas tran vdout0_26ck197 FIND v(dout0_26) AT=1980.05n

* CHECK dout0_27 Vdout0_27ck197 = 1.8 time = 1980
.meas tran vdout0_27ck197 FIND v(dout0_27) AT=1980.05n

* CHECK dout0_28 Vdout0_28ck197 = 1.8 time = 1980
.meas tran vdout0_28ck197 FIND v(dout0_28) AT=1980.05n

* CHECK dout0_29 Vdout0_29ck197 = 0 time = 1980
.meas tran vdout0_29ck197 FIND v(dout0_29) AT=1980.05n

* CHECK dout0_30 Vdout0_30ck197 = 1.8 time = 1980
.meas tran vdout0_30ck197 FIND v(dout0_30) AT=1980.05n

* CHECK dout0_31 Vdout0_31ck197 = 1.8 time = 1980
.meas tran vdout0_31ck197 FIND v(dout0_31) AT=1980.05n

* CHECK dout0_32 Vdout0_32ck197 = 0 time = 1980
.meas tran vdout0_32ck197 FIND v(dout0_32) AT=1980.05n

* CHECK dout0_0 Vdout0_0ck198 = 0 time = 1990
.meas tran vdout0_0ck198 FIND v(dout0_0) AT=1990.05n

* CHECK dout0_1 Vdout0_1ck198 = 0 time = 1990
.meas tran vdout0_1ck198 FIND v(dout0_1) AT=1990.05n

* CHECK dout0_2 Vdout0_2ck198 = 0 time = 1990
.meas tran vdout0_2ck198 FIND v(dout0_2) AT=1990.05n

* CHECK dout0_3 Vdout0_3ck198 = 1.8 time = 1990
.meas tran vdout0_3ck198 FIND v(dout0_3) AT=1990.05n

* CHECK dout0_4 Vdout0_4ck198 = 0 time = 1990
.meas tran vdout0_4ck198 FIND v(dout0_4) AT=1990.05n

* CHECK dout0_5 Vdout0_5ck198 = 0 time = 1990
.meas tran vdout0_5ck198 FIND v(dout0_5) AT=1990.05n

* CHECK dout0_6 Vdout0_6ck198 = 0 time = 1990
.meas tran vdout0_6ck198 FIND v(dout0_6) AT=1990.05n

* CHECK dout0_7 Vdout0_7ck198 = 1.8 time = 1990
.meas tran vdout0_7ck198 FIND v(dout0_7) AT=1990.05n

* CHECK dout0_8 Vdout0_8ck198 = 1.8 time = 1990
.meas tran vdout0_8ck198 FIND v(dout0_8) AT=1990.05n

* CHECK dout0_9 Vdout0_9ck198 = 0 time = 1990
.meas tran vdout0_9ck198 FIND v(dout0_9) AT=1990.05n

* CHECK dout0_10 Vdout0_10ck198 = 1.8 time = 1990
.meas tran vdout0_10ck198 FIND v(dout0_10) AT=1990.05n

* CHECK dout0_11 Vdout0_11ck198 = 1.8 time = 1990
.meas tran vdout0_11ck198 FIND v(dout0_11) AT=1990.05n

* CHECK dout0_12 Vdout0_12ck198 = 0 time = 1990
.meas tran vdout0_12ck198 FIND v(dout0_12) AT=1990.05n

* CHECK dout0_13 Vdout0_13ck198 = 0 time = 1990
.meas tran vdout0_13ck198 FIND v(dout0_13) AT=1990.05n

* CHECK dout0_14 Vdout0_14ck198 = 0 time = 1990
.meas tran vdout0_14ck198 FIND v(dout0_14) AT=1990.05n

* CHECK dout0_15 Vdout0_15ck198 = 0 time = 1990
.meas tran vdout0_15ck198 FIND v(dout0_15) AT=1990.05n

* CHECK dout0_16 Vdout0_16ck198 = 0 time = 1990
.meas tran vdout0_16ck198 FIND v(dout0_16) AT=1990.05n

* CHECK dout0_17 Vdout0_17ck198 = 0 time = 1990
.meas tran vdout0_17ck198 FIND v(dout0_17) AT=1990.05n

* CHECK dout0_18 Vdout0_18ck198 = 0 time = 1990
.meas tran vdout0_18ck198 FIND v(dout0_18) AT=1990.05n

* CHECK dout0_19 Vdout0_19ck198 = 1.8 time = 1990
.meas tran vdout0_19ck198 FIND v(dout0_19) AT=1990.05n

* CHECK dout0_20 Vdout0_20ck198 = 0 time = 1990
.meas tran vdout0_20ck198 FIND v(dout0_20) AT=1990.05n

* CHECK dout0_21 Vdout0_21ck198 = 1.8 time = 1990
.meas tran vdout0_21ck198 FIND v(dout0_21) AT=1990.05n

* CHECK dout0_22 Vdout0_22ck198 = 1.8 time = 1990
.meas tran vdout0_22ck198 FIND v(dout0_22) AT=1990.05n

* CHECK dout0_23 Vdout0_23ck198 = 0 time = 1990
.meas tran vdout0_23ck198 FIND v(dout0_23) AT=1990.05n

* CHECK dout0_24 Vdout0_24ck198 = 0 time = 1990
.meas tran vdout0_24ck198 FIND v(dout0_24) AT=1990.05n

* CHECK dout0_25 Vdout0_25ck198 = 1.8 time = 1990
.meas tran vdout0_25ck198 FIND v(dout0_25) AT=1990.05n

* CHECK dout0_26 Vdout0_26ck198 = 0 time = 1990
.meas tran vdout0_26ck198 FIND v(dout0_26) AT=1990.05n

* CHECK dout0_27 Vdout0_27ck198 = 1.8 time = 1990
.meas tran vdout0_27ck198 FIND v(dout0_27) AT=1990.05n

* CHECK dout0_28 Vdout0_28ck198 = 1.8 time = 1990
.meas tran vdout0_28ck198 FIND v(dout0_28) AT=1990.05n

* CHECK dout0_29 Vdout0_29ck198 = 0 time = 1990
.meas tran vdout0_29ck198 FIND v(dout0_29) AT=1990.05n

* CHECK dout0_30 Vdout0_30ck198 = 1.8 time = 1990
.meas tran vdout0_30ck198 FIND v(dout0_30) AT=1990.05n

* CHECK dout0_31 Vdout0_31ck198 = 1.8 time = 1990
.meas tran vdout0_31ck198 FIND v(dout0_31) AT=1990.05n

* CHECK dout0_32 Vdout0_32ck198 = 0 time = 1990
.meas tran vdout0_32ck198 FIND v(dout0_32) AT=1990.05n

* CHECK dout0_0 Vdout0_0ck202 = 0 time = 2030
.meas tran vdout0_0ck202 FIND v(dout0_0) AT=2030.05n

* CHECK dout0_1 Vdout0_1ck202 = 0 time = 2030
.meas tran vdout0_1ck202 FIND v(dout0_1) AT=2030.05n

* CHECK dout0_2 Vdout0_2ck202 = 0 time = 2030
.meas tran vdout0_2ck202 FIND v(dout0_2) AT=2030.05n

* CHECK dout0_3 Vdout0_3ck202 = 1.8 time = 2030
.meas tran vdout0_3ck202 FIND v(dout0_3) AT=2030.05n

* CHECK dout0_4 Vdout0_4ck202 = 0 time = 2030
.meas tran vdout0_4ck202 FIND v(dout0_4) AT=2030.05n

* CHECK dout0_5 Vdout0_5ck202 = 0 time = 2030
.meas tran vdout0_5ck202 FIND v(dout0_5) AT=2030.05n

* CHECK dout0_6 Vdout0_6ck202 = 0 time = 2030
.meas tran vdout0_6ck202 FIND v(dout0_6) AT=2030.05n

* CHECK dout0_7 Vdout0_7ck202 = 1.8 time = 2030
.meas tran vdout0_7ck202 FIND v(dout0_7) AT=2030.05n

* CHECK dout0_8 Vdout0_8ck202 = 1.8 time = 2030
.meas tran vdout0_8ck202 FIND v(dout0_8) AT=2030.05n

* CHECK dout0_9 Vdout0_9ck202 = 0 time = 2030
.meas tran vdout0_9ck202 FIND v(dout0_9) AT=2030.05n

* CHECK dout0_10 Vdout0_10ck202 = 1.8 time = 2030
.meas tran vdout0_10ck202 FIND v(dout0_10) AT=2030.05n

* CHECK dout0_11 Vdout0_11ck202 = 1.8 time = 2030
.meas tran vdout0_11ck202 FIND v(dout0_11) AT=2030.05n

* CHECK dout0_12 Vdout0_12ck202 = 0 time = 2030
.meas tran vdout0_12ck202 FIND v(dout0_12) AT=2030.05n

* CHECK dout0_13 Vdout0_13ck202 = 0 time = 2030
.meas tran vdout0_13ck202 FIND v(dout0_13) AT=2030.05n

* CHECK dout0_14 Vdout0_14ck202 = 0 time = 2030
.meas tran vdout0_14ck202 FIND v(dout0_14) AT=2030.05n

* CHECK dout0_15 Vdout0_15ck202 = 0 time = 2030
.meas tran vdout0_15ck202 FIND v(dout0_15) AT=2030.05n

* CHECK dout0_16 Vdout0_16ck202 = 0 time = 2030
.meas tran vdout0_16ck202 FIND v(dout0_16) AT=2030.05n

* CHECK dout0_17 Vdout0_17ck202 = 0 time = 2030
.meas tran vdout0_17ck202 FIND v(dout0_17) AT=2030.05n

* CHECK dout0_18 Vdout0_18ck202 = 0 time = 2030
.meas tran vdout0_18ck202 FIND v(dout0_18) AT=2030.05n

* CHECK dout0_19 Vdout0_19ck202 = 1.8 time = 2030
.meas tran vdout0_19ck202 FIND v(dout0_19) AT=2030.05n

* CHECK dout0_20 Vdout0_20ck202 = 0 time = 2030
.meas tran vdout0_20ck202 FIND v(dout0_20) AT=2030.05n

* CHECK dout0_21 Vdout0_21ck202 = 1.8 time = 2030
.meas tran vdout0_21ck202 FIND v(dout0_21) AT=2030.05n

* CHECK dout0_22 Vdout0_22ck202 = 1.8 time = 2030
.meas tran vdout0_22ck202 FIND v(dout0_22) AT=2030.05n

* CHECK dout0_23 Vdout0_23ck202 = 0 time = 2030
.meas tran vdout0_23ck202 FIND v(dout0_23) AT=2030.05n

* CHECK dout0_24 Vdout0_24ck202 = 0 time = 2030
.meas tran vdout0_24ck202 FIND v(dout0_24) AT=2030.05n

* CHECK dout0_25 Vdout0_25ck202 = 1.8 time = 2030
.meas tran vdout0_25ck202 FIND v(dout0_25) AT=2030.05n

* CHECK dout0_26 Vdout0_26ck202 = 0 time = 2030
.meas tran vdout0_26ck202 FIND v(dout0_26) AT=2030.05n

* CHECK dout0_27 Vdout0_27ck202 = 1.8 time = 2030
.meas tran vdout0_27ck202 FIND v(dout0_27) AT=2030.05n

* CHECK dout0_28 Vdout0_28ck202 = 1.8 time = 2030
.meas tran vdout0_28ck202 FIND v(dout0_28) AT=2030.05n

* CHECK dout0_29 Vdout0_29ck202 = 0 time = 2030
.meas tran vdout0_29ck202 FIND v(dout0_29) AT=2030.05n

* CHECK dout0_30 Vdout0_30ck202 = 1.8 time = 2030
.meas tran vdout0_30ck202 FIND v(dout0_30) AT=2030.05n

* CHECK dout0_31 Vdout0_31ck202 = 1.8 time = 2030
.meas tran vdout0_31ck202 FIND v(dout0_31) AT=2030.05n

* CHECK dout0_32 Vdout0_32ck202 = 0 time = 2030
.meas tran vdout0_32ck202 FIND v(dout0_32) AT=2030.05n

* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
